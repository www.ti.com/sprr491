# Allegro board PROC135A_BRD.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PR0_PRU0_GPO7: length 129.3
  TOP w0.132: U18.P21 v1(41.88,111.66)
  L10_SIG03 w0.102: v1(41.88,111.66) U18.P21 41.48,110.7 41.71,110.47 42.07,110.47 42.28,110.25 42.28,109.9 42.51,109.67 42.9,109.67 43.08,109.49 43.08,108.22 43.23,108.07 43.74,108.07 43.88,107.93 43.88,105.88 44.1,105.66 44.45,105.66 44.68,105.43 44.68,105.07 44.89,104.86 45.28,104.86 45.48,104.67 45.48,104.17 46.34,103.31 46.82,103.31 47.08,103.05 47.08,102.7 47.31,102.47 47.74,102.47 47.91,102.3 47.91,101.77 48.08,101.6 48.08,101.23 49.08,100.24 49.22,100.24 53.21,96.26 53.21,90.83 51.18,88.8 51.18,84.48 52.69,82.97 52.69,74.49 58.43,68.75 58.43,67.95 60.56,65.83 64.94,65.83 69.24,61.52 69.24,54.32 68.71,53.79 68.71,52.74 66.8,50.84 66.8,41.62 65.66,40.47 65.66,38.26 63.8,36.4 63.29,36.4 62.17,35.29 62.17,34.32 61.44,33.58 55.97,33.58 55.15,34.41 40.78,34.41 40.07,33.7 34.25,33.7 v1(33.54,32.99)
  BOTTOM w0.14: RA6.8 v1(33.54,32.99)
REFCLK1_R: length 5.4
  TOP w0.14: R55.2 26.6,112.6 28.73,110.47 U18.A20
RES_LM5141: length 2.2
  BOTTOM w0.14: U89.24 33.03,43.35 32.67,42.99 32.08,42.99 31.87,42.78 C427.1
RESETSTATZ: length 282
  TOP w0.132: U18.F19 v1(34.68,110.06)
  TOP w0.14: R171.2 v1(61.13,45.5) 61.45,45.17 63.09,45.17 TP65.1 63.72,44.55 R173.1 64.38,44.83 64.57,45.02 65.38,45.02 66.53,43.88 66.53,41.77 R178.1 ; U2.28 50.51,153.58 v1(51.01,154.08) ; U11.2 v1(41.66,124.33) ; U24.3 6.64,91.77 6.75,91.88 8.04,91.88 v1(8.43,92.27) ; U5.3 v1(43.42,145.66) ; U32.2 v1(61.06,70.07)
  L03_SIG01 w0.102: v1(43.42,145.66) 45.51,145.66 47.04,147.19 47.04,150.96 49.69,153.61 50.53,153.61 v1(51.01,154.08) ; v1(55.11,38.47) 54.8,38.17 53.9,38.17 53.49,38.59 52.47,38.59 51.44,39.62 50.53,39.62 49.07,41.09 47.51,41.09 46.59,42.01 v1(46.59,42.86)
  L05_SIG02 w0.102: v1(61.06,70.07) 60.58,69.58 60.58,67.04 60.1,66.56 60.1,47.66 61.13,46.64 v1(61.13,45.5) ; v1(17.06,114.52) 16.18,114.52 14,112.33 14,111.67 11.55,109.23 11.55,108.2 9.04,105.69 9.04,100.22 9.27,99.99 9.27,97.63 8.98,97.33 8.98,95.21 8.88,95.12 8.88,93.31 8.43,92.86 v1(8.43,92.27) ; v1(59.24,71.89) 59.24,73.13 63.47,77.37 63.47,79.79 62.72,80.55 62.72,84.44 62.31,84.85 62.31,86.07 60.86,87.52 60.48,87.52 59.57,88.43 59.57,90.84 59.34,91.07 59.34,97.55 59.67,97.88 59.67,99.76 60.05,100.14 60.05,105.63 58.24,107.43 58.24,108.98 56.67,110.55 v1(55.53,110.55)
  L10_SIG03 w0.102: v1(61.13,45.5) 61.13,41.05 61.42,40.76 61.42,40.22 61.2,40 58.74,40 58.07,39.33 57.25,39.33 56.4,38.47 v1(55.11,38.47) ; v1(59.24,71.89) v1(61.06,70.07) ; v1(43.42,145.66) 46.82,145.66 47.4,146.24 49.3,146.24 51.68,143.87 51.68,141.34 50.18,139.85 49.79,139.85 48.69,138.75 47.09,138.75 45.75,137.4 44.92,137.4 43.17,135.66 v1(43.17,135.41) ; v1(55.53,110.55) 55.2,110.88 55.2,112.05 54.66,112.59 54.66,115.11 53.87,115.91 53.87,117.46 50.45,120.87 49.51,120.87 47.47,122.91 46.05,122.91 45.2,123.76 44.07,123.76 43.86,123.97 42.02,123.97 v1(41.66,124.33) 40.28,125.71 32.73,125.71 32.31,126.12 26.65,126.12 25.73,125.2 25.72,125.2 25.66,125.13 21.9,125.13 17.93,121.17 17.93,116.73 17.25,116.05 17.25,114.71 v1(17.06,114.52) 17.25,114.33 17.25,113.49 17.7,113.05 17.7,112.62 18.26,112.06 18.6,112.06 19.2,111.45 19.2,111.1 19.72,110.58 24.45,110.58 24.7,110.83 25.56,110.83 25.89,111.16 26.37,111.16 27.51,112.31 27.51,114.7 28.39,115.59 31.64,115.59 34.28,112.95 34.28,110.46 v1(34.68,110.06)
  BOTTOM w0.14: v1(55.11,38.47) 54.7,38.88 U92.28 ; v1(46.59,42.86) 46.59,41.95 45.95,41.31 U94.2 ; v1(61.13,45.5) 60.72,45.1 60.72,44.34 60.93,44.13 R430.1 61.21,42.88 U93.2 ; v1(43.17,135.41) 43.17,135.37 43.94,134.6 43.94,132.31 43.67,132.03 43.67,126.33 v1(41.66,124.33)
RT_LM5141: length 1.7
  BOTTOM w0.14: R423.1 30.71,45.86 U89.4
SCL_XDS_TA: length 39.6
  TOP w0.14: R612.2 v1(48.62,49.21) 48.6,49.24 R503.2
  L03_SIG01 w0.102: v1(58.86,30.6) 59.35,31.09 59.35,34.14 60.45,35.25 60.45,36.03 60.52,36.1 60.52,36.8 60.45,36.87 60.45,37.77 60.32,37.9 59.61,38.61 58.41,38.61 56.12,40.9 52.87,40.9 51.22,42.54 51.22,45.5 49.75,46.97 49.75,48.08 v1(48.62,49.21)
  BOTTOM w0.14: U87.7 48.78,50.03 48.62,49.87 v1(48.62,49.21) ; v1(58.86,30.6) 58.41,30.15 58.41,28.07 58.22,27.88 58.22,25.87 59.65,24.44 60.34,24.44 61.16,23.62 R614.2
SDA_XDS_TA: length 42.7
  TOP w0.14: R613.2 v1(47.63,49.21) 47.9,49.48 47.9,49.85 R502.2
  L03_SIG01 w0.102: v1(47.63,49.21) 48.27,48.57 48.94,48.57 49.52,47.99 49.52,46.88 51,45.4 51,42.45 52.77,40.67 56.03,40.67 58.31,38.38 59.51,38.38 60.23,37.67 60.23,36.77 60.29,36.71 60.29,36.19 60.23,36.13 60.23,35.47 59.23,34.47 58.74,34.47 58.44,34.17 58.44,32.99 58.46,32.97 58.46,32.64 58.44,32.62 58.44,32.45 58.34,32.35 58.34,32.02 58.44,31.92 58.44,30.05 v1(58.01,29.62)
  BOTTOM w0.14: v1(58.01,29.62) 58.01,28.08 57.93,28 57.93,25.75 59.53,24.15 60.2,24.15 61,23.35 61,23.28 61.28,22.99 61.99,22.99 62.17,23.17 R615.2 ; U87.6 47.51,49.85 47.63,49.73 v1(47.63,49.21)
SEL_XDS: length 42.7
  L03_SIG01 w0.102: v1(65.67,18.72) 65.18,18.24 63.32,18.24 63.02,18.54 63.02,21.69 63.48,22.15 63.48,22.76 65.23,24.51 65.48,24.51 66.74,25.77 v1(67.34,25.77) ; v1(46.63,21.4) 46.97,21.06 51.5,21.06 52.17,21.72 v1(55.72,21.72)
  L05_SIG02 w0.102: v1(55.72,21.72) 56.71,20.73 60.08,20.73 60.17,20.82 61,20.82 61.73,20.09 63.58,20.09 64.4,19.28 65.12,19.28 v1(65.67,18.72)
  BOTTOM w0.14: v1(55.72,21.72) 57.04,21.72 57.29,21.47 U109.4 ; U103.4 67.55,25.86 67.46,25.77 v1(67.34,25.77) ; U106.5 48.28,24.5 48.14,24.36 48.14,24.09 47.01,22.96 47.01,21.78 v1(46.63,21.4) ; U111.16 66.34,18.9 66.16,18.72 v1(65.67,18.72) 65.67,19.44 65.96,19.73 U111.1
SEL_XDS110_INV: length 72.5
  TOP w0.14: J19.8 v1(39.89,6.34)
  L03_SIG01 w0.102: v1(69.78,23.61) 68.99,22.82 68.84,22.82 65.31,19.29 64.23,19.29 v1(63.64,18.7) ; v1(43.39,16.09) 44.73,16.09 45.58,16.94 45.58,19.36 46.78,20.56 v1(47.25,20.56)
  L05_SIG02 w0.102: v1(39.89,6.34) 39.89,10.57 40.46,11.14 40.46,13.17 v1(43.39,16.09) 44.38,15.09 48.76,15.09 50,16.33 50.9,16.33 51.96,15.28 53.33,15.28 53.94,15.89 59.35,15.89 60.14,16.68 61.25,16.68 63.28,18.7 v1(63.64,18.7) ; v1(44.97,24.83) 47.84,21.95 47.84,21.15 v1(47.25,20.56)
  BOTTOM w0.14: v1(63.64,18.7) 63.51,18.84 U112.5 ; U107.2 45.12,24.21 44.97,24.35 v1(44.97,24.83) ; U117.2 42.79,15.49 v1(43.39,16.09) ; v1(69.78,23.61) 69.78,24.68 70.01,24.91 R498.1 R497.2 71.26,25.28 71.4,25.42 71.4,26.28 71.17,26.51 U103.2 ; U114.16 47.22,19.89 47.03,20.08 47.03,20.34 v1(47.25,20.56) 48,20.56 48.26,20.3 U114.1 ; U122.4 40.33,7.7 39.89,7.26 v1(39.89,6.34)
SLOW_CLK: length 15.7
  TOP w0.14: J2.50 v1(11.42,146.79)
  L03_SIG01 w0.102: v1(11.42,146.79) 18.53,139.68 18.53,137.11 v1(19.43,136.21)
  BOTTOM w0.14: R280.2 v1(19.43,136.21)
SOC_CLKIN: length 49.6
  TOP w0.14: R35.2 C19.1 R36.2 34.36,134.83 34.19,134.66 v1(33.79,134.66) ; v1(27.54,107.13) 27.54,106.26 26.93,105.64 R69.1
  BOTTOM w0.14: v1(27.54,107.13) 27.54,118.48 30.81,121.76 30.81,133.14 32.33,134.66 v1(33.79,134.66)
SOC_DVDD1V8: length 52.6
  TOP w0.279: U27.37 v1(12.09,79.04)
  TOP w0.305: v1(24.86,108.95) 24.86,108.55 C528.1 ; C32.1 26.58,107.51 v1(26.7,107.63) 26.58,107.75 C528.3 26.71,108.55 v1(26.71,108.95)
  TOP w0.356: U18.T8 v1(43.48,100.47) ; U18.F12 v1(34.68,104.46) ; U18.K15 v1(37.88,106.86) ; U18.H16 v1(36.28,107.66) ; U18.U8 v1(44.28,100.47) ; U18.H17 v1(36.28,108.46) ; U18.L16 v1(38.68,107.66)
  L03_SIG01 w0.14: v1(34.68,104.46) 34.28,104.86 31.05,104.86 30.81,104.62 29.1,104.62 27.03,102.55 26.49,102.55 23.56,99.63 23.56,98.47 22.16,97.08 21.78,97.08 21.29,96.58 21.29,87.96 19.93,86.6 16.55,86.6 13.13,83.19 13.13,80.03 12.14,79.04 v1(12.09,79.04)
  BOTTOM w0.254: C225.1 39.09,108.17 C218.1 ; C529.1 26.61,108.95 v1(26.71,108.95) ; v1(24.86,108.95) 24.95,108.95 C529.3
  BOTTOM w0.305: C225.1 38.69,107.66 v1(38.68,107.66) ; v1(36.28,108.46) 36.3,108.48 C217.1 ; C221.1 36.08,107.87 v1(36.28,107.66) ; 43.65,100.6 43.62,100.6 v1(43.48,100.47) ; v1(34.68,104.46) 34.68,104.06 C258.1 ; 44.48,100.26 v1(44.28,100.47)
  vias: v1(3.28,88.99) v1(3.28,88.07) v1(4.15,88.99) v1(4.15,88.07) v1(5.01,88.99) v1(5.01,88.07) v1(28.4,78.17) v1(28.4,77.26)
SOC_DVDD3V3: length 16.6
  TOP w0.305: C41.1 v1(20.32,101.33) ; C522.1 18.51,102.34 v1(18.35,102.19) ; C522.3 v1(20.74,102.91)
  TOP w0.356: U18.F9 v1(34.68,101.27) ; U18.L15 v1(38.68,106.86) ; U18.U13 v1(44.28,105.26) ; U18.M15 v1(40.28,106.86) ; U18.H10 v1(36.28,102.07) ; U18.H13 v1(36.28,105.26) ; U18.N15 v1(41.08,106.86) ; U18.G14 v1(35.48,106.06) ; U18.U10 v1(44.28,102.07) ; U18.G11 v1(35.48,102.87) ; U18.T13 v1(43.48,105.26) ; U18.R13 v1(42.68,105.26)
  L07_PWR02 w0.165: 43.8,102.47 43.17,102.47
  L07_PWR02 w0.406: v1(38.68,106.86) v1(40.28,106.86) ; v1(36.28,105.26) v1(35.48,106.06)
  BOTTOM w0.305: C238.1 44.4,105.39 v1(44.28,105.26) ; v1(34.68,101.27) 34.68,101.51 C276.1 ; v1(41.08,106.86) 41.2,106.99 C229.1 ; 35.68,102.97 35.59,102.97 v1(35.48,102.87) 35.26,103.09 C257.1 ; v1(40.28,106.86) 40.24,106.82 C232.1 ; v1(42.68,105.26) 42.8,105.39 C239.1 ; C270.1 44.47,101.88 v1(44.28,102.07) ; C247.1 v1(36.28,105.26) ; C240.1 v1(35.48,106.06) ; C244.1 v1(43.48,105.26) ; C523.3 36.39,102.17 v1(36.28,102.07) ; C233.1 38.72,106.82 v1(38.68,106.86)
  vias: v1(12.55,99.94) v1(12.55,99.28) v1(13.36,99.94) v1(13.36,99.03) v1(14.28,99.94) v1(14.28,99.03)
SOC_EMU0: length 156.6
  TOP w0.132: U18.C13 v1(32.28,105.26)
  TOP w0.14: v1(49.34,22.65) R224.2 51.15,23.31 52.41,24.57 54.54,24.57 v1(55.43,23.69)
  L03_SIG01 w0.102: v1(31.7,60.62) 32.13,61.05 37.1,61.05 37.85,60.3 37.85,47.3 39.42,45.73 39.42,41.49 38.08,40.15 38.08,37.83 36.76,36.51 36.76,35.65 35.79,34.68 35.79,31.51 34.8,30.52 34.8,26.4 34.44,26.05 34.44,25.01 31.71,22.27 31.71,18.72 32.91,17.52 36.5,17.52 37.74,18.76 39.73,18.76 44.48,23.51 48.48,23.51 v1(49.34,22.65)
  L05_SIG02 w0.102: v1(31.7,60.62) 31.52,60.44 22.21,60.44 21.49,61.16 20.87,61.78 20.87,65.77 21.24,66.13 21.24,70.46 21.59,70.81 21.59,74.69 20.98,75.3 20.98,88.79 20.43,89.34 20.43,95.06 21.35,95.98 21.35,100.83 22.13,101.6 22.13,102.11 23.79,103.78 28.82,103.78 29.11,103.49 30.59,103.49 31.07,103.96 31.67,103.96 31.88,104.17 31.88,104.86 v1(32.28,105.26)
  BOTTOM w0.14: U106.2 v1(49.34,22.65) ; v1(55.43,23.69) 56.3,22.82 57.29,22.82 58.06,22.05 60.51,22.05 61.13,21.43 62.07,21.43 62.81,20.7 U112.2
SOC_EMU1: length 146
  TOP w0.132: U18.E10 v1(33.88,102.07)
  TOP w0.14: v1(55.31,24.58) 54.95,24.94 48.24,24.94 47.98,24.69 47.98,23.58 48.14,23.42 48.32,23.42 R223.2 48.42,22.88 48.41,22.88 v1(48.41,22.8)
  L03_SIG01 w0.102: v1(33.78,60.57) 34,60.78 36.91,60.78 37.51,60.18 37.51,46.18 38.41,45.28 38.41,41.11 37.65,40.35 37.65,37.91 36.43,36.69 36.43,35.9 35.38,34.86 35.38,33.9 34.95,33.47 34.95,31.51 33.89,30.44 33.89,24.91 31.31,22.33 31.31,17.88 31.92,17.27 36.71,17.27 37.89,18.46 39.86,18.46 42.92,21.51 46.04,21.51 46.63,22.1 47.71,22.1 v1(48.41,22.8)
  L05_SIG02 w0.102: v1(33.78,60.57) 33.48,60.87 33.48,62.8 32.64,63.64 29.06,63.64 28.4,64.3 28.4,65.57 28.12,65.85 28.12,69.56 24.24,73.43 24.24,91.69 24.41,91.86 24.41,94.91 25.64,96.14 25.64,98.42 27.09,99.86 28.84,99.86 29.67,100.69 30.35,100.69 30.53,100.87 32.48,100.87 32.68,101.06 32.68,101.44 32.9,101.66 33.48,101.66 v1(33.88,102.07)
  BOTTOM w0.14: v1(48.41,22.8) 48.67,22.8 48.99,23.12 U106.3 ; v1(55.31,24.58) 56.03,23.87 60.08,23.87 60.71,23.23 60.71,22.32 61.19,21.84 62.42,21.84 63.16,21.11 U112.3
SOC_GPIO1_49: length 22.6
  TOP w0.132: U18.D18 v1(33.08,109.26)
  L03_SIG01 w0.102: v1(33.08,109.26) 32.68,108.86 30.42,108.86 27.97,106.41 27.15,106.41 25.4,104.66 18.05,104.66 17.35,105.36 v1(17.35,106.85)
  BOTTOM w0.14: v1(17.35,106.85) 17.75,106.85 17.79,106.81 R324.2 18.77,106.81 19.15,107.18 R323.1
SOC_I2C0_SCL: length 173.9
  TOP w0.132: U18.D17 v1(33.08,108.46) ; U38.6 v1(22.05,52.99)
  TOP w0.14: v1(41.63,133.44) 41.99,133.09 41.99,132.46 42.25,132.2 J3.28
  L03_SIG01 w0.102: v1(14.18,68.19) 13.24,67.25 13.24,59.76 18.05,54.95 18.05,54.03 18.84,53.24 21.79,53.24 v1(22.05,52.99) ; v1(9.25,86.63) 8.85,87.03 8.85,91.09 10.16,92.41 10.51,92.41 10.52,92.42 14.36,92.42 15.52,93.59 15.52,95.64 11.95,99.22 11.95,102.05 12.99,103.09 v1(12.99,104.43)
  L10_SIG03 w0.102: v1(9.25,86.63) 8.81,86.19 8.81,85.47 9.25,85.03 10.59,85.03 13.21,82.41 13.21,69.16 v1(14.18,68.19) ; v1(41.63,133.44) 40.87,134.2 34.93,134.2 33.72,132.98 24.08,132.98 23.07,134 19,134 18.82,133.82 18.82,132.98 18.09,132.25 16.51,132.25 15.73,131.46 15.73,127.83 15.05,127.15 13.7,127.15 10.89,124.34 10.89,122.66 10.56,122.33 10.56,120.55 10.76,120.35 10.76,119.66 9.04,117.94 9.04,111.77 9.41,111.4 9.41,111.4 10.36,110.46 10.36,107.06 v1(12.99,104.43) 14.45,102.96 19.75,102.96 20.23,102.48 22.11,102.48 23.33,103.7 25.75,103.7 26.9,104.85 30.83,104.85 31.08,105.1 31.08,105.49 31.26,105.67 31.65,105.67 31.88,105.9 31.88,106.31 32.03,106.47 32.45,106.47 32.68,106.7 32.68,106.99 32.68,107.03 32.91,107.26 33.22,107.26 33.25,107.26 33.48,107.5 33.48,108.06 v1(33.08,108.46)
  BOTTOM w0.14: v1(9.25,86.63) 9.65,86.63 12.79,83.49 R363.1 ; v1(22.05,52.99) R408.2 22.6,53.27 22.81,53.48 23.5,53.48 24.01,52.97 24.01,52.26 26.14,50.13 26.14,48.88 26.27,48.76 26.27,47.36 26.04,47.13 R421.1
SOC_I2C0_SCL_PMIC: length 18.7
  TOP w0.132: U27.31 12.18,82.04 12.12,82.11 v1(12.09,82.11)
  TOP w0.14: v1(14.32,66.87) 14.32,66.87 TP43.1
  L10_SIG03 w0.102: v1(12.09,82.11) 12.71,81.49 12.71,68.48 v1(14.32,66.87)
  BOTTOM w0.14: R363.2 12.38,81.85 12.12,82.11 v1(12.09,82.11)
SOC_I2C0_SDA: length 183.1
  TOP w0.132: v1(22.05,52.22) 21.78,52.49 U38.5 ; U18.E16 v1(33.88,107.66)
  TOP w0.14: J3.27 43.54,129.5 43.54,132.06 43.13,132.48 v1(43.13,133.37)
  L03_SIG01 w0.102: v1(22.05,52.22) 22.48,52.66 22.48,53.13 21.17,54.44 18.93,54.44 15.42,57.95 15.42,67.32 v1(15.85,67.76) ; v1(12.26,103.86) 12.25,103.86 12.25,102.68 11.72,102.15 11.72,99.12 15.29,95.54 15.29,93.68 14.35,92.74 9.98,92.74 7.97,90.72 7.97,87.04 v1(9.25,85.76)
  L10_SIG03 w0.102: v1(43.13,133.37) 43.13,134.06 42.47,134.71 34.78,134.71 33.51,133.44 25.61,133.44 23.8,135.24 18.58,135.24 15.81,132.48 14.1,132.48 13.02,131.4 13.02,127.13 10.43,124.53 10.43,122.86 8.59,121.02 8.59,111.58 9.22,110.95 9.38,110.79 9.38,106.39 10.98,104.79 11.34,104.79 v1(12.26,103.86) 13.11,103.86 14.29,102.69 19.64,102.69 20.08,102.24 22.2,102.24 23.42,103.47 25.85,103.47 26.97,104.59 30.98,104.59 31.25,104.86 31.65,104.86 31.88,105.1 31.88,105.44 32.11,105.67 32.45,105.67 32.68,105.9 32.68,106.23 32.91,106.46 33.25,106.46 33.48,106.7 33.48,107.03 33.88,107.43 v1(33.88,107.66) ; v1(9.25,85.76) 10.42,85.76 14.06,82.13 14.06,74.59 13.61,74.14 13.61,69.56 15.42,67.76 v1(15.85,67.76)
  BOTTOM w0.14: v1(9.25,85.76) 9.65,85.76 11.58,83.83 R362.1 ; v1(22.05,52.22) 21.95,52.12 R409.2 21.49,53.1 22.2,53.81 23.68,53.81 24.34,53.15 24.34,52.41 27.13,49.62 27.13,47.36 26.14,46.37 R422.1
SOC_I2C0_SDA_PMIC: length 20.8
  TOP w0.132: v1(12.09,82.87) 12.42,82.54 U27.30
  TOP w0.14: v1(15.88,66.89) 16.24,66.89 TP44.1
  L10_SIG03 w0.102: v1(12.09,82.87) 12.97,81.99 12.97,68.85 14.93,66.89 v1(15.88,66.89)
  BOTTOM w0.14: v1(12.09,82.87) 11.99,82.76 R362.2
SOC_I2C1_SCL: length 332.9
  TOP w0.132: U18.C17 v1(32.28,108.46) ; U13.1 16.19,111.79 15.89,111.48 v1(15.89,111.28)
  TOP w0.14: U25.A1 3,90.02 v1(3.15,89.87) ; v1(20.78,106.08) 20.5,106.36 20.5,106.82 20.1,107.22 U16.1 ; U2.29 v1(50.01,153.17) ; v1(4.96,104.2) 5.33,104.2 U17.A1 ; U17.C3 v1(6.69,106.04) ; TP49.1 v1(79.41,54.11) ; U29.1 v1(38.44,73.87)
  L03_SIG01 w0.102: v1(41.67,68.34) 41.25,67.92 41.25,66.5 40.91,66.16 40.41,66.16 v1(39.87,66.7) 39.87,72.44 v1(38.44,73.87) ; v1(3.15,89.87) 2.88,89.6 2.88,87.91 3.88,86.91 5.13,86.91 7.96,84.08 7.96,80.55 7.68,80.27 7.68,73.27 4.52,70.12 3.76,70.12 v1(2.85,71.03)
  L05_SIG02 w0.102: v1(30.53,66.65) 31.31,67.43 v1(32.49,67.43) 34.28,67.43 v1(35.07,66.65) 35.64,67.22 36.25,67.22 37.19,66.28 39.45,66.28 v1(39.87,66.7) 40.32,67.15 41.1,67.15 41.73,66.51 45.51,66.51 46.22,65.8 46.22,61.77 47.53,60.47 47.53,53.6 47.12,53.19 47.12,52.5 49.12,50.5 v1(49.12,44.39) 49.79,44.39 51.21,42.97 51.21,42.05 52.96,40.3 53.41,40.3 v1(54.2,39.51) 54.71,39 55.63,39 56.47,38.16 58.95,38.16 60.68,36.44 63.78,36.44 65.91,38.56 65.91,41.97 65.56,42.31 65.56,43.86 67.66,45.95 67.66,49.18 69.33,50.86 78,50.86 79.41,52.27 v1(79.41,54.11) ; v1(4.96,104.2) 4.96,106.97 5.34,107.35 5.34,115.81 8.03,118.5 8.03,120.16 10.26,122.39 10.26,125.59 7.6,128.26 7.6,131.73 6.32,133.01 6.32,138.5 5.16,139.66 3.63,139.66 3.33,139.96 3.33,146.55 7.93,151.15 26.68,151.15 28.18,152.66 36.51,152.66 37.01,152.16 38.76,152.16 40.53,153.93 46.72,153.93 47.49,153.17 v1(50.01,153.17)
  L10_SIG03 w0.102: v1(32.28,108.46) 31.88,108.86 31.88,109.5 31.72,109.66 31.2,109.66 30.83,110.03 27.16,110.03 25.04,107.91 23.08,107.91 21.25,106.08 v1(20.78,106.08) 19.03,106.08 16.72,108.4 16.72,110.48 15.92,111.28 v1(15.89,111.28) ; v1(4.96,104.2) 5.18,103.97 5.18,94.74 3.09,92.65 3.09,91.82 3.59,91.33 3.59,90.32 v1(3.15,89.87)
  BOTTOM w0.14: v1(41.67,68.34) 41.67,68.09 41.51,67.93 U83.C3 ; v1(49.12,44.39) R433.2 48.6,44.9 48.78,45.08 U87.2 ; U85.B3 32.39,67.53 v1(32.49,67.43) 33.33,67.43 33.58,67.17 33.58,66.21 33.17,65.8 29.36,65.8 28.43,66.74 27.1,66.74 26.18,65.82 24.92,65.82 24.82,65.92 13.42,65.92 12.21,67.14 9.8,67.14 6.89,70.04 3.89,70.04 2.9,71.03 v1(2.85,71.03) 3.1,71.29 U82.A1 ; R406.1 v1(79.41,54.11) ; U85.A1 v1(30.53,66.65) ; v1(4.96,104.2) 5.08,104.32 5.08,104.43 v1(6.69,106.04) 7.05,105.68 9.41,105.68 9.91,106.18 15.6,106.18 16.36,105.42 19.59,105.42 20.26,106.08 v1(20.78,106.08) ; U84.A1 v1(35.07,66.65) ; U92.29 v1(54.2,39.51) ; U83.A1 v1(39.87,66.7)
SOC_I2C1_SDA: length 328
  TOP w0.132: v1(16.69,111.25) U13.2 ; U18.E17 v1(33.88,108.46)
  TOP w0.14: U29.6 v1(37.68,73.87) ; v1(4.37,104.85) 4.68,105.16 U17.A2 ; U16.6 20.1,106.46 v1(20.02,106.54) ; TP50.1 v1(80.43,54.11) ; v1(50.01,154.08) 49.51,153.58 U2.30 ; U25.A2 v1(2.22,89.42)
  L03_SIG01 w0.102: v1(40.7,66.65) 40.7,72.86 39.14,74.41 38.22,74.41 v1(37.68,73.87) ; v1(3.63,70.96) 4.88,70.96 7.45,73.52 7.45,80.95 7.73,81.23 7.73,83.99 5.04,86.68 3.79,86.68 2.63,87.84 2.63,89.01 v1(2.22,89.42)
  L05_SIG02 w0.102: v1(31.41,66.65) 31.41,66.65 31.73,66.97 33.2,66.97 33.94,66.23 35.53,66.23 v1(35.95,66.65) 36.59,66 40.06,66 v1(40.7,66.65) 41.15,66.19 45.38,66.19 45.99,65.58 45.99,61.58 47.21,60.36 47.21,53.6 46.36,52.75 46.36,48.13 47.02,47.47 v1(47.02,44.69) 48.11,44.69 v1(54.2,38.6) 54.91,37.89 58.91,37.89 60.73,36.06 63.83,36.06 64.06,35.83 65.64,35.83 66.88,37.07 66.88,44.46 68.27,45.85 68.27,49.15 69.67,50.55 78.61,50.55 80.43,52.38 v1(80.43,54.11) ; v1(50.01,154.08) 49.32,153.39 47.59,153.39 46.83,154.16 40.35,154.16 38.61,152.41 37.21,152.41 36.68,152.95 28.04,152.95 26.55,151.46 7.77,151.46 2.98,146.68 2.98,139.86 3.41,139.43 5.06,139.43 6.07,138.43 6.07,132.93 7.37,131.64 7.37,128.06 9.96,125.46 9.96,122.49 7.67,120.21 7.67,118.53 5.11,115.96 5.11,107.58 4.7,107.18 4.7,105.56 4.37,105.23 v1(4.37,104.85)
  L10_SIG03 w0.102: v1(33.88,108.46) 33.88,108.55 33.48,108.95 33.48,109.46 33.28,109.66 32.85,109.66 32.68,109.84 32.68,110.24 32.46,110.46 31.11,110.46 30.92,110.28 26.31,110.28 25.24,109.2 25.24,108.8 25.01,108.57 24.11,108.57 23.95,108.73 22.68,108.73 21.31,107.35 20.83,107.35 v1(20.02,106.54) 19.76,106.54 17.04,109.26 17.04,110.91 v1(16.69,111.25) ; v1(4.37,104.85) 4.37,104.15 4.85,103.67 4.85,94.83 2.72,92.69 2.72,90.68 2.22,90.18 v1(2.22,89.42)
  BOTTOM w0.14: U92.30 53.7,39.1 v1(54.2,38.6) ; v1(47.02,44.69) 47.32,44.39 R434.2 47.71,44.93 47.51,45.12 U87.3 ; R405.1 v1(80.43,54.11) ; U82.A2 3.5,71.09 v1(3.63,70.96) 6.07,70.96 6.53,70.49 7.28,70.49 10.11,67.65 12.27,67.65 13.62,66.3 24.59,66.3 25.36,67.07 28.68,67.07 29.59,66.16 30.92,66.16 v1(31.41,66.65) U85.A2 ; v1(4.37,104.85) 4.49,104.85 5.2,105.57 5.2,106.29 5.59,106.68 6.75,106.68 7.19,106.24 9.35,106.24 9.58,106.46 15.86,106.46 16.56,105.77 19.24,105.77 v1(20.02,106.54) ; U83.A2 v1(40.7,66.65) ; U84.A2 v1(35.95,66.65)
SOC_I2C1_TA_SCL: length 46
  TOP w0.14: R612.1 v1(48.62,47.55)
  L03_SIG01 w0.102: v1(48.62,47.55) 48.62,45.54 50.36,43.79 50.36,42.3 52.55,40.11 55.21,40.11 55.8,39.53 55.8,38.87 56.74,37.93 59.32,37.93 59.66,37.59 v1(59.66,36.45) 59.25,36.45 58.8,36.9 57.36,36.9 55.78,35.32 55.78,29.45 54.42,28.09 54.42,25.22 53.21,24.01 53.21,23.04 53.48,22.76 v1(54.53,22.76)
  BOTTOM w0.14: v1(54.53,22.76) 54.53,19.62 56.25,17.91 56.25,16.85 55.83,16.43 R545.1
SOC_I2C1_TA_SDA: length 46.7
  TOP w0.14: R613.1 v1(47.63,47.55)
  L03_SIG01 w0.102: v1(47.63,47.55) 48.16,48.09 48.84,48.09 49.09,47.83 49.09,45.39 50.59,43.89 50.59,42.39 52.64,40.34 55.31,40.34 56.03,39.62 56.03,38.96 56.83,38.16 59.42,38.16 60,37.58 60,36.68 60.06,36.61 60.06,36.28 60,36.22 60,35.89 v1(59.66,35.56) 58.78,35.56 58.04,36.3 57.37,36.3 56.06,34.99 56.06,29.17 54.82,27.93 54.82,24.37 v1(53.68,23.23)
  BOTTOM w0.14: R550.1 53.29,17.6 53.68,17.99 v1(53.68,23.23)
SOC_I2C2_SCL: length 29
  TOP w0.132: U18.M22 v1(40.28,112.46)
  TOP w0.14: U5.12 43.42,137.48 v1(43.31,137.37)
  BOTTOM w0.14: v1(43.31,137.37) 43.31,137.37 R279.2 43.03,136.81 42.69,136.47 42.69,134.94 43.54,134.09 43.54,132.5 43.37,132.34 43.37,127.2 41.13,124.96 41.13,118.89 40.78,118.54 40.78,112.96 v1(40.28,112.46)
SOC_I2C2_SDA: length 32.1
  TOP w0.132: U18.M20 v1(40.28,110.86)
  TOP w0.14: U5.13 v1(44.07,137.39)
  BOTTOM w0.14: v1(40.28,110.86) 40.68,111.26 40.68,112 41.19,112.51 41.19,118.47 41.57,118.85 41.57,121.9 43.94,124.27 43.94,125.36 46,127.42 46,134.56 45.57,134.99 45.57,136.01 44.76,136.81 R278.2 44.07,137.39 v1(44.07,137.39)
SOC_MMC0_CLK: length 2.1
  TOP w0.14: U18.AB7 48.26,99.69 v1(49.15,99.69)
  BOTTOM w0.14: v1(49.15,99.69) 49.4,99.94 R343.2
SOC_MMC0_CMD: length 32.8
  TOP w0.132: U18.Y6 v1(46.68,98.87)
  TOP w0.14: v1(56.67,77.51) 56.67,77.26 U28.M5
  L05_SIG02 w0.102: v1(46.68,98.87) 47.08,98.47 47.65,98.47 47.88,98.24 47.88,97.9 48.11,97.67 48.49,97.67 48.77,97.38 48.77,96.87 51.66,93.98 51.66,92.15 50.53,91.02 50.53,81.18 51.36,80.35 51.54,80.35 51.77,80.57 51.94,80.57 52.07,80.45 52.07,80.27 51.85,80.04 51.85,79.86 51.97,79.74 52.15,79.74 52.38,79.96 52.56,79.96 52.68,79.84 52.68,79.66 52.46,79.43 52.46,79.25 52.58,79.13 52.76,79.13 52.99,79.35 53.17,79.35 53.29,79.23 53.29,79.05 53.07,78.82 53.07,78.64 53.56,78.15 54.84,78.15 55.48,77.51 v1(56.67,77.51)
  BOTTOM w0.14: R372.2 v1(56.67,77.51)
SOC_MMC0_DAT0: length 32.9
  TOP w0.132: U18.AA6 v1(47.48,98.87)
  TOP w0.14: U28.A3 55.92,82.89 53.4,85.41 v1(53.4,85.72) R113.2
  L05_SIG02 w0.102: v1(53.4,85.72) 53.67,85.45 53.67,83.22 53.21,82.76 53.21,81.54 52.96,81.29 51.13,81.29 50.83,81.58 50.83,90.89 51.97,92.03 51.97,94.13 49.1,97 49.1,97.84 48.08,98.87 v1(47.48,98.87)
SOC_MMC0_DAT1: length 33.5
  TOP w0.102: U28.A4 56.42,83.31
  TOP w0.14: U18.AB6 48.33,98.81 v1(50.03,98.81) ; R115.2 v1(54.92,85.76) 55.7,84.98 55.7,84.02 56.42,83.31
  L05_SIG02 w0.102: v1(50.03,98.81) 50.33,98.52 50.33,97.58 53.19,94.72 53.19,88.88 54.59,87.48 54.59,85.99 54.03,85.44 54.03,83.08 53.64,82.68 53.64,80.98 53.87,80.75 54.68,80.75 54.92,81 v1(54.92,85.76)
SOC_MMC0_DAT2: length 33.3
  TOP w0.14: U28.A5 56.92,83.26 57.09,83.43 57.09,85.53 v1(56.5,86.12) 56.5,86.65 R117.2 ; U18.Y7 v1(46.68,99.67)
  L05_SIG02 w0.102: v1(56.5,86.12) 56.5,85.75 56.83,85.41 56.83,83.58 56.37,83.11 55.8,83.11 55.35,83.57 55.35,85.95 55.16,86.13 55.16,87.52 53.55,89.13 53.55,94.81 50.74,97.62 50.74,98.71 49.37,100.08 49.04,100.08 48.25,100.87 46.43,100.87 46.28,100.72 U18.Y7 v1(46.68,99.67)
SOC_MMC0_DAT3: length 32.9
  TOP w0.081: U28.B2 55.17,82.26 55.17,82.7
  TOP w0.132: U18.AA7 v1(47.48,99.67)
  TOP w0.14: 55.17,82.7 54.94,82.93 54.66,82.93 51.88,85.72 v1(51.88,85.73) R111.2
  L05_SIG02 w0.102: v1(47.48,99.67) 48.17,99.67 49.71,98.12 49.71,97.25 52.58,94.38 52.58,91.79 52.57,91.78 52.57,91.77 51.45,90.65 51.45,87.11 51.56,87 51.99,87 52.11,86.88 52.11,86.72 52,86.62 51.56,86.62 51.45,86.51 51.45,83.94 51.71,83.69 52.45,83.69 52.55,83.79 52.55,84.03 52.45,84.14 51.92,84.14 51.81,84.25 51.81,84.41 51.92,84.52 52.45,84.52 52.56,84.63 52.56,84.79 52.45,84.9 51.92,84.9 51.81,85.01 51.81,85.17 51.92,85.28 52.45,85.28 52.56,85.39 52.56,85.6 52.39,85.78 51.92,85.78 v1(51.88,85.73)
SOC_MMC0_DAT4: length 32.6
  TOP w0.081: 55.67,82.7 55.67,82.26 U28.B3
  TOP w0.132: U18.Y8 v1(46.68,100.47)
  TOP w0.14: R112.2 v1(52.64,86.17) 52.64,85.53 54.85,83.31 55.05,83.31 55.67,82.7
  L05_SIG02 w0.102: v1(46.68,100.47) 47.08,100.07 48.22,100.07 50.02,98.26 50.02,97.4 52.89,94.53 52.89,91.23 52.77,91.12 52.58,91.12 52.46,91.01 52.46,90.85 52.58,90.74 52.77,90.74 52.89,90.63 52.89,90.37 52.77,90.26 51.93,90.26 51.82,90.15 51.82,89.99 51.93,89.88 52.77,89.88 52.89,89.77 52.89,89.61 52.77,89.5 51.93,89.5 51.82,89.39 51.82,89.23 51.93,89.12 52.77,89.12 52.89,89.01 52.89,88.85 52.77,88.74 51.93,88.74 51.82,88.63 51.82,88.47 51.93,88.36 52.49,88.36 52.59,88.26 52.59,87.46 52.75,87.31 53.88,87.31 54,87.2 54,87.04 53.89,86.93 52.75,86.93 52.64,86.82 v1(52.64,86.17)
SOC_MMC0_DAT5: length 32.7
  TOP w0.081: 56.17,82.93 56.17,82.26 U28.B4
  TOP w0.132: U18.W7 v1(45.88,99.67)
  TOP w0.14: 56.17,82.93 56.17,83.09 55.26,84 55.26,84.83 54.16,85.93 v1(54.16,86.17) R114.2
  L05_SIG02 w0.102: v1(54.16,86.17) 53.27,86.17 53.01,85.91 53.01,84.92 53.35,84.58 53.35,83.52 53.05,83.21 51.68,83.21 51.14,83.76 51.14,90.77 52.28,91.9 52.28,94.26 49.41,97.12 49.41,97.65 49.41,97.99 48.14,99.26 46.28,99.26 v1(45.88,99.67)
SOC_MMC0_DAT6: length 32.5
  TOP w0.081: 56.67,83.4 56.67,82.26 U28.B5
  TOP w0.132: U18.W9 v1(45.88,101.26)
  TOP w0.14: R116.2 v1(55.69,86.17) 56.67,85.18 56.67,83.4
  L05_SIG02 w0.102: v1(45.88,101.26) 46.28,101.67 48.05,101.67 49.27,100.44 49.53,100.44 50.95,99.02 50.95,98.94 51.41,98.48 51.41,97.42 53.88,94.95 53.88,89.35 56.09,87.13 56.09,85.63 56.52,85.21 56.52,84.04 56.33,83.86 55.84,83.86 55.68,84.01 55.68,86.17 v1(55.69,86.17)
SOC_MMC0_DAT7: length 33.4
  TOP w0.081: 57.36,83.31 57.17,83.12 57.17,82.26 U28.B6
  TOP w0.14: 57.36,83.31 57.5,83.44 57.5,85.91 v1(57.3,86.11) 57.3,86.61 R118.2 ; v1(49.47,100.86) U18.AB8
  L05_SIG02 w0.102: v1(57.3,86.11) 57.76,86.11 58.29,85.58 58.29,82.84 57.96,82.5 57.45,82.5 57.23,82.72 57.23,85.56 56.9,85.9 56.9,86.85 54.21,89.54 54.21,95.09 51.72,97.58 51.72,98.61 51.27,99.05 51.27,99.29 49.69,100.86 v1(49.47,100.86)
SOC_MMC2_CLK: length 2.5
  TOP w0.14: v1(35.48,113.39) 36.3,112.57 36.3,112.45 U18.H22
  BOTTOM w0.14: R316.1 35.61,113.52 v1(35.48,113.39)
SOC_OSPI_DQ0: length 7.7
  TOP w0.132: U18.J21 v1(37.08,111.66)
  TOP w0.14: RA1.7 35.86,116.91 v1(36.4,116.37)
  L05_SIG02 w0.102: v1(37.08,111.66) 37.08,112.67 37.64,113.23 37.64,115.14 v1(36.4,116.37)
SOC_OSPI_DQ1: length 11.3
  TOP w0.132: U18.J18 v1(37.08,109.26)
  TOP w0.14: v1(39.09,117.25) 38.82,117.25 38.68,117.39 RA2.8
  L05_SIG02 w0.102: v1(37.08,109.26) 37.08,109.49 37.48,109.89 37.48,110.26 37.68,110.46 38.03,110.46 38.05,110.47 38.28,110.7 38.28,111.07 38.47,111.26 38.51,111.26 39.03,111.26 39.65,111.89 39.65,112.94 39.56,113.03 39.56,116.77 v1(39.09,117.25)
SOC_OSPI_DQ2: length 9.9
  TOP w0.132: U18.J19 v1(37.08,110.07)
  TOP w0.14: RA2.7 38.28,116.91 v1(38.82,116.37)
  L05_SIG02 w0.102: v1(38.82,116.37) 38.92,116.28 38.92,112.84 39.09,112.67 39.09,112.3 38.85,112.07 38.54,112.07 38.54,112.06 38.51,112.06 38.28,111.83 38.28,111.5 38.05,111.26 37.71,111.26 37.48,111.03 37.48,110.73 37.48,110.72 37.48,110.69 37.08,110.29 v1(37.08,110.07)
SOC_OSPI_DQ3: length 10.3
  TOP w0.132: U18.H18 v1(36.28,109.26)
  TOP w0.14: RA1.6 35.46,116.91 v1(34.92,116.37)
  L05_SIG02 w0.102: v1(36.28,109.26) 36.28,109.5 35.88,109.9 35.88,111.83 36.26,112.21 36.26,115.03 v1(34.92,116.37)
SOC_OSPI_DQ4: length 7.4
  TOP w0.132: U18.K21 v1(37.88,111.66)
  TOP w0.14: RA2.5 37.48,117.43 v1(37.34,117.29)
  L05_SIG02 w0.102: v1(37.34,117.29) 37.83,116.8 37.83,116.11 38.28,115.65 38.28,112.4 38.28,112.28 37.88,111.88 v1(37.88,111.66)
SOC_OSPI_DQ5: length 9.3
  TOP w0.132: U18.H19 v1(36.28,110.06)
  TOP w0.14: RA1.5 35.06,117.43 v1(34.92,117.29)
  L05_SIG02 w0.102: v1(36.28,110.06) 36.68,110.46 36.68,115.06 35.56,116.18 35.56,116.64 v1(34.92,117.29)
SOC_OSPI_DQ6: length 8.4
  TOP w0.132: U18.J20 v1(37.08,110.86)
  TOP w0.14: RA2.6 37.88,116.91 v1(37.34,116.37)
  L05_SIG02 w0.102: v1(37.34,116.37) 37.34,116.07 37.94,115.47 37.94,113.09 37.48,112.63 37.48,111.53 37.48,111.48 37.08,111.08 v1(37.08,110.86)
SOC_OSPI_DQ7: length 6.7
  TOP w0.132: U18.J22 37.08,112.47 37.08,113.38 v1(37.14,113.44)
  TOP w0.14: v1(36.4,117.29) 36.26,117.43 RA1.8
  L05_SIG02 w0.102: v1(37.14,113.44) 37.14,115.07 36.02,116.19 36.02,116.9 v1(36.4,117.29)
SOC_PORZ: length 46.7
  L03_SIG01 w0.102: v1(51.33,36.99) 53.12,36.99 53.67,36.44 53.67,35.47 52.96,34.76 52.96,29 47.83,23.87 44.37,23.87 39.63,19.13 37.62,19.13 37.05,18.56 v1(32.58,18.56)
  BOTTOM w0.14: v1(32.58,18.56) 31.44,18.56 30.62,17.74 30.62,16.76 31.01,16.37 R544.2 31.84,16.37 31.93,16.46 U116.4 ; U96.3 56.41,37.53 56.26,37.68 54.57,37.68 54.44,37.55 54.44,36.99 54.3,36.85 52.24,36.85 52.1,36.99 51.77,36.99 51.76,36.99 v1(51.33,36.99)
SOC_RGMII_MDC: length 59.7
  TOP w0.132: U18.V12 v1(45.08,104.46)
  TOP w0.14: v1(63.87,111.27) 63.87,111.43 63.26,112.05 R606.1 ; R108.1 63.26,89.49 63.87,88.88 v1(63.87,88.71)
  L03_SIG01 w0.102: v1(45.08,104.46) 45.48,104.86 48.7,104.86 48.94,104.63 48.94,104.62 49.25,104.31 50.84,104.31 51.57,103.57 52.6,103.57 53.52,102.65 53.52,98.5 53.39,98.37 53.39,97.33 54.26,96.47 54.26,91.28 55.43,90.11 57.78,90.11 58.35,89.54 58.35,89.04 58.83,88.56 60.18,88.56 60.53,88.21 63.37,88.21 v1(63.87,88.71)
  L05_SIG02 w0.102: v1(63.87,111.27) 62.16,109.55 62.16,100.78 61.85,100.47 61.85,100.12 62.05,99.91 62.05,98.02 62.46,97.62 62.46,90.84 62.74,90.56 62.74,89.84 v1(63.87,88.71)
SOC_RGMII_MDIO: length 56.5
  TOP w0.132: U18.V13 v1(45.08,105.26)
  TOP w0.14: R608.1 60.85,111.33 v1(60.91,111.27) ; v1(60.91,88.71) 60.85,88.78 R107.1
  L03_SIG01 w0.102: v1(60.91,88.71) 60.91,89.47 60.52,89.86 58.92,89.86 58.4,90.38 55.53,90.38 54.48,91.42 54.48,96.64 53.9,97.23 53.9,97.58 54.39,98.07 54.39,102.54 52.3,104.63 49.41,104.63 48.38,105.67 45.48,105.67 v1(45.08,105.26)
  L05_SIG02 w0.102: v1(60.91,88.71) 60.91,89.34 60.33,89.93 60.33,97.63 61.19,98.49 61.19,99.58 60.99,99.78 60.71,99.78 60.43,100.06 60.43,100.52 60.89,100.98 60.89,102.12 61.06,102.3 61.06,103.24 60.86,103.44 60.86,106.21 60.45,106.62 60.45,110.81 v1(60.91,111.27)
SOC_SPI0_CLK: length 89.9
  TOP w0.14: v1(29.72,107.2) 29.72,107.68 30.28,108.24 30.9,108.24 U18.A17
  L10_SIG03 w0.102: v1(47.99,136.65) 47.99,135.8 44.36,132.17 37.19,132.17 36.49,132.87 34.91,132.87 34.11,132.07 24.21,132.07 23.64,132.07 22.86,132.86 21.27,132.86 20.63,132.21 20.63,127.85 19.28,126.51 14.04,126.51 11.64,124.11 11.64,122.35 12.27,121.72 12.27,112.03 11.38,111.14 11.38,110.4 11.75,110.03 11.75,108.69 16.08,104.36 20.1,104.36 20.66,103.8 21.5,103.8 22.11,104.41 25.35,104.41 27.13,106.19 28.7,106.19 v1(29.72,107.2)
  BOTTOM w0.14: v1(47.99,136.65) 48.43,136.21 50.64,136.21 50.87,136.44 U55.4
SOC_SPI0_CS0: length 105.4
  TOP w0.132: U18.D16 v1(33.08,107.66)
  L10_SIG03 w0.102: v1(58.91,139.51) 52.94,139.51 52.06,138.63 50.32,138.63 49.51,137.82 48.15,137.82 47.33,136.99 47.33,135.87 44.09,132.63 37.49,132.63 36.79,133.33 34.71,133.33 33.91,132.53 24.02,132.53 23.83,132.53 22.99,133.36 21.06,133.36 20.37,132.68 19.2,132.68 17.96,131.43 17.96,127.6 17.31,126.95 13.83,126.95 11.12,124.23 11.12,122.56 10.86,122.31 10.86,120.68 11.07,120.48 11.07,119.49 9.27,117.69 9.27,111.86 10.72,110.41 10.72,107.4 14.93,103.19 19.56,103.19 19.67,103.31 21.19,103.31 21.63,102.86 22.08,102.86 23.15,103.93 25.66,103.93 27.4,105.67 30.85,105.67 31.08,105.9 31.08,106.23 31.31,106.46 31.65,106.46 31.88,106.7 31.88,107.03 32.11,107.26 32.6,107.26 33,107.66 v1(33.08,107.66)
  BOTTOM w0.14: U55.9 58.43,139.04 v1(58.91,139.51)
SOC_SPI0_D0: length 92.2
  TOP w0.132: U18.B15 v1(31.48,106.86)
  L10_SIG03 w0.102: v1(50.78,138.21) 50.16,137.59 48.36,137.59 47.58,136.81 47.58,135.71 44.26,132.4 37.34,132.4 36.64,133.1 34.81,133.1 34.01,132.3 24.12,132.3 23.93,132.3 23.74,132.3 22.93,133.11 21.13,133.11 20.42,132.4 19.38,132.4 18.29,131.31 18.29,127.5 17.54,126.74 13.95,126.74 11.35,124.14 11.35,122.41 11.12,122.18 11.12,120.86 11.37,120.6 11.37,119.26 9.5,117.39 9.5,111.96 11.09,110.37 11.09,108.79 15.76,104.13 19.71,104.13 20.29,103.55 21.58,103.55 22.21,104.18 25.59,104.18 27.36,105.96 30.01,105.96 30.51,106.47 30.85,106.47 31.25,106.86 v1(31.48,106.86)
  BOTTOM w0.14: U55.7 50.95,138.39 v1(50.78,138.21)
SOC_SPI2_CLK: length 118.8
  TOP w0.132: U18.A21 30.68,111.66 v1(30.3,111.66)
  TOP w0.14: U54.8 26.68,39.01 v1(26.89,39.22)
  L05_SIG02 w0.102: v1(26.89,39.22) 26.61,38.94 24.99,38.94 24.04,37.99 23.01,37.99 22.73,38.27 22.73,38.82 23.47,39.56 23.47,46.71 23.06,47.12 22.77,47.12 22.43,47.45 22.43,47.87 22.16,48.14 18.1,48.14 16.2,50.03 15.28,50.03 14.2,51.11 14.2,53.73 11.28,56.66 9.95,56.66 5.5,61.1 5.5,67.87 6.21,68.58 6.21,76.79 8.54,79.12 8.54,87.35 7.98,87.91 7.98,89.05 9.01,90.09 9.01,92.93 9.24,93.16 9.24,95.04 9.28,95.08 9.28,97.21 9.58,97.5 9.58,100.12 9.35,100.34 9.35,105.5 13.03,109.18 13.03,109.96 14.32,111.24 14.32,112.22 15.11,113.01 16.08,113.01 16.63,113.56 20.62,113.56 21.16,114.1 24.55,114.1 25.84,112.81 26.16,112.81 27.31,111.66 v1(30.3,111.66)
  BOTTOM w0.14: v1(26.89,39.22) 26.45,39.66 26.25,39.66 25.88,40.03 U95.7
SOC_SPI2_CS0: length 110.2
  TOP w0.132: U18.B21 v1(31.48,111.66)
  TOP w0.14: v1(23.22,38.46) 23.47,38.21 U54.6
  L05_SIG02 w0.102: v1(31.48,111.66) 31.08,111.26 27.28,111.26 26.04,112.51 25.71,112.51 24.98,113.24 16.76,113.24 16.22,112.7 15.28,112.7 14.69,112.11 14.69,111.17 13.86,110.34 13.86,109.58 9.65,105.37 9.65,100.5 9.88,100.27 9.88,97 10.19,96.69 10.19,96.41 10.05,96.27 10.05,93.5 9.39,92.84 9.39,88.62 8.85,88.08 8.85,78.99 6.52,76.67 6.52,68.45 5.81,67.75 5.81,61.22 10.05,56.99 11.41,56.99 14.51,53.89 14.51,52.19 18.23,48.46 22.68,48.46 23.79,47.34 23.79,39.02 v1(23.22,38.46)
  BOTTOM w0.14: v1(23.22,38.46) 23.61,38.08 U95.4
SOC_SPI2_D0: length 117.5
  TOP w0.132: U18.C19 v1(32.28,110.06)
  TOP w0.14: U54.7 24.67,38.61 25.33,37.95 26.43,37.95 v1(26.91,38.43)
  L05_SIG02 w0.102: v1(32.28,110.06) 32.07,110.06 31.67,110.46 30.85,110.46 30.6,110.71 26.59,110.71 25.63,111.67 25.17,111.67 24.52,112.32 17.01,112.32 16.86,112.48 15.44,112.48 14.95,111.99 14.95,111.06 14.68,110.8 14.68,109.66 9.94,104.92 9.94,100.55 10.11,100.38 10.11,97.09 10.42,96.79 10.42,96.31 10.28,96.17 10.28,93.41 9.82,92.95 9.82,85.43 9.08,84.69 9.08,78.9 6.81,76.64 6.81,68.36 6.17,67.71 6.17,61.19 10.14,57.21 11.53,57.21 14.73,54.01 14.73,52.28 18.33,48.69 22.92,48.69 24.08,47.53 24.08,42.4 25.15,41.32 25.15,40.83 26.31,39.68 27.14,39.68 27.4,39.42 27.4,38.92 v1(26.91,38.43)
  BOTTOM w0.14: U95.9 28.3,40.68 27.91,40.28 27.91,39.43 v1(26.91,38.43)
SOC_SPI2_D1: length 116.6
  TOP w0.132: U18.B19 v1(31.48,110.06)
  TOP w0.14: U54.9 23.62,39.68 23.87,39.93 25.98,39.93 26.28,39.63 27.5,39.63 28.7,38.43 v1(28.74,38.43)
  L05_SIG02 w0.102: v1(28.74,38.43) 27.91,39.26 27.91,40.85 25.9,42.86 25.9,46.17 23.14,48.93 18.41,48.93 14.96,52.37 14.96,54.24 11.76,57.44 10.24,57.44 6.44,61.23 6.44,67.67 7.04,68.27 7.04,76.54 9.3,78.81 9.3,84.59 10.04,85.34 10.04,92.76 10.54,93.25 10.54,96.08 11.07,96.61 11.07,98.18 10.39,98.86 10.39,100.43 10.17,100.65 10.17,103.6 10.51,103.94 11.43,103.94 11.98,104.5 12.11,104.5 12.36,104.75 12.36,106.35 14.5,108.49 15.11,108.49 16.15,109.52 16.15,109.94 16.48,110.27 16.48,110.83 16.3,111 16.3,111.67 16.68,112.06 23.9,112.06 25.6,110.36 30.31,110.36 30.6,110.06 v1(31.48,110.06)
  BOTTOM w0.14: U95.12 29.03,38.73 v1(28.74,38.43)
SOC_TCK: length 177.9
  TOP w0.132: U18.A14 v1(30.68,106.07)
  L03_SIG01 w0.102: v1(36.57,60.05) 35.3,60.05 33.26,58.02 33.26,47.88 32.7,47.32 32.7,43.53 33.1,43.13 33.1,38.39 31.61,36.9 31.61,34.67 31.93,34.35 31.93,31.89 30.41,30.37 30.41,26.53 29.77,25.9 29.77,22.62 30.41,21.98 30.41,15.9 32.1,14.2 47.04,14.2 50.27,17.43 50.27,18.22 50.64,18.6 v1(52.42,18.6)
  L05_SIG02 w0.102: v1(36.57,60.05) 36.57,59.77 35.57,58.78 17.69,58.78 15.39,61.07 15.39,65.73 16.37,66.71 16.37,67 18.09,68.72 18.09,70.77 17.5,71.35 17.5,75.79 16.87,76.42 16.87,83.22 16.13,83.96 16.13,84.88 16.58,85.32 16.58,88.32 16.91,88.65 16.91,91.13 16.81,91.24 16.81,92.75 16.46,93.1 16.46,95.66 16.15,95.96 16.15,98.33 16.75,98.94 16.75,101.27 18.49,103.01 19.12,103.01 19.83,103.72 19.83,104 20.74,104.92 21.59,104.92 22.77,106.1 30.65,106.1 v1(30.68,106.07)
  L10_SIG03 w0.102: v1(67.96,22.55) 68.84,22.55 69.09,22.3 69.09,20.9 68.87,20.68 68.05,20.68 67.72,20.36 64.04,20.36 63.6,19.92 60,19.92 59.67,20.25 58.1,20.25 57.43,19.58 56.54,19.58 55.55,18.6 v1(52.42,18.6)
  BOTTOM w0.14: R515.1 67.96,23.02 v1(67.96,22.55) ; v1(52.42,18.6) 51.72,18.6 R529.1
SOC_TDI: length 166.5
  TOP w0.132: U18.A16 v1(30.68,107.66)
  L05_SIG02 w0.102: v1(30.68,107.66) 28.71,107.66 28.22,108.15 24.41,108.15 22.31,110.25 17.79,110.25 17.12,109.57 17.12,108.51 15.85,107.24 15.85,105.93 11.76,101.84 11.76,100.41 11.61,100.27 11.61,99.31 11.61,98.93 12.02,98.52 12.02,96.27 11.5,95.75 11.5,92.66 11.04,92.2 11.04,81.28 10.31,80.56 10.31,77.67 8.37,75.73 8.37,67.6 8.67,67.31 8.67,61.45 10.59,59.53 11.32,59.53 17.7,53.14 17.74,53.14 17.76,53.11 20.56,53.11 22.24,51.44 24.81,51.44 26.09,50.16 27.34,50.16 28.23,49.27 28.23,47.78 30.07,45.94 30.07,35.99 29.19,35.1 29.19,30.88 33.93,26.14 48.77,26.14 49.77,25.14 v1(49.77,17.7)
  L10_SIG03 w0.102: v1(65.78,22.55) 64.19,24.13 52.04,24.13 49.77,21.87 v1(49.77,17.7)
  BOTTOM w0.14: v1(65.78,22.55) 65.98,22.55 66.4,22.13 66.57,22.13 66.74,21.95 U111.6 ; v1(49.77,17.7) 49.46,18.02 U114.9
SOC_TDO: length 180.9
  L03_SIG01 w0.102: v1(35.58,59.62) 35.58,59.13 33.75,57.3 33.75,40.15 34.08,39.82 34.08,38.59 33.34,37.86 33.34,37.02 32.74,36.42 32.74,32.19 30.71,30.16 30.71,16.07 32.27,14.5 46.68,14.5 49.29,17.11 49.29,18.59 50.79,20.09 53.03,20.09 53.73,20.79 v1(55.74,20.79) 55.74,20.32 54.26,18.84 54.26,12.1 50.92,8.77 42.86,8.77 v1(40.77,6.68)
  L05_SIG02 w0.102: v1(35.58,59.62) 35.04,59.08 18.71,59.08 16.64,61.15 16.22,61.15 15.78,61.6 15.78,65.37 16.68,66.27 16.68,66.88 18.39,68.59 18.39,74 19.07,74.68 19.07,76.13 18.02,77.18 18.02,82.44 17.69,82.77 17.44,82.77 17.26,82.94 17.26,83.66 17.8,84.19 17.8,84.8 17.44,85.15 17.44,88.28 17.91,88.75 17.91,91.15 17.67,91.39 17.67,93 17.06,93.61 17.06,100.44 17.48,100.85 18.17,100.85 18.84,101.52 18.84,102.29 20.22,103.67 20.22,103.89 20.93,104.61 21.82,104.61 22.49,105.28 v1(27.84,105.28)
  BOTTOM w0.14: R326.1 v1(27.84,105.28) ; U122.2 41.13,7.81 41.26,7.68 41.26,7.17 v1(40.77,6.68) ; v1(55.74,20.79) 56.22,20.79 56.34,20.67 U109.2
SOC_TDO_R: length 4.2
  TOP w0.132: U18.C14 v1(32.28,106.06)
  BOTTOM w0.14: v1(32.28,106.06) 31.88,105.66 30.19,105.66 29.81,105.28 R326.2
SOC_TMS: length 167.6
  TOP w0.132: U18.B14 v1(31.48,106.06)
  L03_SIG01 w0.102: v1(34.46,60.05) 32.72,58.31 32.72,47.88 32.21,47.37 32.21,37.99 30.94,36.72 30.94,31.36 30.1,30.52 30.1,26.89 28.69,25.47 28.69,22.57 29.39,21.87 29.39,18.68 29.05,18.34 29.05,16.81 31.97,13.89 47.35,13.89 50.77,17.31 v1(50.77,17.72)
  L05_SIG02 w0.102: v1(34.46,60.05) 34.23,59.82 21.97,59.82 20.44,61.35 20.44,65.43 19.83,66.05 19.83,70.61 20.53,71.31 20.53,73.95 19.92,74.56 19.92,84.46 18.51,85.87 18.51,88.53 18.28,88.76 18.28,90.69 18.28,90.69 18.28,90.88 18.5,91.11 18.5,94.24 17.91,94.83 17.91,100.22 18.31,100.62 18.54,100.62 19.75,101.83 19.75,102.79 20.71,103.75 21.43,103.75 22.56,104.88 28.6,104.88 29.39,105.67 30.85,105.67 31.25,106.06 v1(31.48,106.06)
  L10_SIG03 w0.102: v1(68.52,21.9) 68.18,21.55 65.41,21.55 65.13,21.28 64.27,21.28 63.88,21.67 61.86,21.67 60.96,20.77 56.56,20.77 56.05,21.28 51.98,21.28 50.77,20.07 v1(50.77,17.72)
  BOTTOM w0.14: U111.8 67.54,21.74 67.69,21.9 v1(68.52,21.9) ; v1(50.77,17.72) 50.74,17.75 50.74,18.22 50.27,18.69 U114.8
SOC_TRST#: length 139.8
  TOP w0.132: U18.F15 v1(34.68,106.86)
  L03_SIG01 w0.102: v1(49.89,59.93) 48.87,58.92 48.87,54.06 48.42,53.61 48.42,52.63 46.19,50.41 46.19,48.22 46.86,47.55 46.86,45.83 46.19,45.17 46.19,42.02 47.35,40.86 48.97,40.86 50.44,39.39 51.15,39.39 53.98,36.56 53.98,35.35 53.19,34.56 53.19,26.1 51.67,24.58 v1(51.67,22.65)
  L05_SIG02 w0.102: v1(51.67,22.65) 53.2,22.65 53.59,22.26 55.89,22.26 56.41,21.73 63.82,21.73 64.21,22.12 65.22,22.12 66.23,21.1 v1(68.51,21.1) ; v1(34.68,106.86) 35.08,106.46 35.08,101.07 34.88,100.87 34.49,100.87 34.28,100.66 34.28,100.3 34.05,100.07 33.7,100.07 33.48,99.85 33.48,99.49 33.26,99.27 30.3,99.27 29.62,98.58 26.81,98.58 26.33,98.1 26.33,95.76 25.22,94.65 25.22,91.4 24.95,91.12 24.95,82.32 28.17,79.09 34.04,79.09 34.89,78.24 38.94,78.24 49.08,68.11 49.08,60.75 v1(49.89,59.93)
  BOTTOM w0.14: U111.9 68.33,20.93 v1(68.51,21.1) ; U114.6 51.08,19.49 R526.1 51.1,19.94 51.67,20.51 v1(51.67,22.65)
SOC_UART0_RX_3V3: length 140.3
  TOP w0.132: U18.E14 v1(33.88,106.06)
  L05_SIG02 w0.102: v1(33.88,106.06) 33.48,106.47 32.91,106.47 32.68,106.7 32.68,107.83 32.45,108.07 31.31,108.07 31,108.38 29.26,108.38 28,109.64 25.48,109.64 25.35,109.51 24.87,109.51 23.67,110.71 17.6,110.71 16.66,109.76 16.66,109.31 13.48,106.13 13.48,104.29 12.54,103.35 11.55,103.35 10.67,102.47 10.67,100.84 10.96,100.55 10.96,98.94 11.55,98.34 11.55,96.45 11.05,95.94 11.05,93.03 10.51,92.5 10.51,81.63 9.76,80.88 9.76,78.61 7.72,76.57 7.72,67.53 7.45,67.25 7.45,60.92 9.74,58.64 11.36,58.64 15.42,54.57 15.42,53.15 16.03,52.54 17.34,52.54 19.04,50.85 23.77,50.85 25.35,49.26 25.35,48.2 27.67,45.88 27.67,42.01 29.44,40.23 29.44,37.33 28.15,36.04 26.42,36.04 23.96,33.58 23.96,29.79 22.38,28.21 22.38,14.79 v1(22.07,14.49)
  BOTTOM w0.14: v1(22.07,14.49) 21.53,14.49 21.11,14.07 U119.8
SOC_UART0_TX_3V3: length 141.8
  TOP w0.132: U18.D15 v1(33.08,106.86)
  L05_SIG02 w0.102: v1(33.08,106.86) 33.48,107.27 33.48,107.86 33.28,108.07 32.91,108.07 32.68,108.3 32.68,108.65 32.47,108.86 29.45,108.86 28.31,110.01 25.55,110.01 23.83,111.73 17.46,111.73 17.09,111.36 17.09,110.51 16.43,109.86 16.43,109.49 12.64,105.69 12.64,104.63 12.28,104.27 12.22,104.27 12.08,104.27 10.4,102.59 10.4,100.74 10.63,100.51 10.63,98.94 11.32,98.26 11.32,96.53 10.79,96.01 10.79,93.13 10.29,92.62 10.29,81.98 9.53,81.22 9.53,78.71 7.35,76.53 7.35,68.2 6.69,67.53 6.69,61.31 10.33,57.67 11.92,57.67 15.19,54.4 15.19,52.98 16.34,51.83 17.73,51.83 19.61,49.96 22.43,49.96 23.2,49.19 24.17,49.19 24.47,48.89 24.47,48.25 26.79,45.93 26.79,42.43 29.15,40.06 29.15,38.19 28.93,37.97 28.64,37.97 28.34,37.67 28.34,37.17 28.09,36.92 26.12,36.92 23.61,34.41 23.61,33.85 20.17,30.41 v1(20.17,14.86)
  BOTTOM w0.14: U119.6 20.31,14.72 v1(20.17,14.86) 20.38,15.07 R558.2
SOC_UART1_CTS: length 40.9
  TOP w0.14: TP91.1 v1(30.13,6.97)
  L03_SIG01 w0.102: v1(30.13,6.97) 28.38,8.73 28.38,10.74 28.2,10.92 28.2,18.12 27.6,18.72 27.6,19.38 28.83,20.61 28.83,21.73 28.16,22.4 28.16,25.83 29.64,27.31 29.64,30.9 30.48,31.74 30.48,37.17 29.86,37.8 28.45,37.8 v1(27.81,38.43)
  BOTTOM w0.14: v1(27.81,38.43) 27.81,38.83 29.01,40.03 U95.10 ; v1(30.13,6.97) 29.85,6.97 29.72,7.1 U123.9
SOC_UART1_CTS_BT: length 135.3
  TOP w0.14: v1(14.09,36.65) 14.18,36.65 14.66,37.13 16.14,37.13 16.9,37.89 18.21,37.89 18.93,38.61 U54.14 ; v1(6.03,143.53) 6.77,142.79 J2.34
  L03_SIG01 w0.102: v1(6.03,143.53) 5.36,142.87 5.36,137.36 4.73,136.73 4.73,133.28 7.28,130.73 7.28,127.5 9.88,124.89 9.88,122.32 9.13,121.56 9.13,110.99 10.32,109.79 10.32,106.88 1.07,97.62 1.07,92.93 1.36,92.63 1.36,91.55 0.77,90.96 0.77,60.54 6.54,54.78 10.25,54.78 10.79,54.25 10.79,53.33 11.74,52.37 11.74,39 v1(14.09,36.65)
SOC_UART1_RTS: length 34.8
  TOP w0.14: TP90.1 29.75,8.44 v1(29.58,8.27)
  L03_SIG01 w0.102: v1(29.58,8.27) 29.58,9.86 28.43,11.01 28.43,18.97 29.06,19.61 29.06,21.82 28.44,22.45 28.44,25.78 29.87,27.22 29.87,30.7 30.71,31.53 30.71,37.32 v1(31.34,37.95)
  BOTTOM w0.14: U123.7 29.78,8.06 v1(29.58,8.27) ; v1(31.34,37.95) 31.22,38.08 U95.13
SOC_UART1_RTS_BT: length 134.8
  TOP w0.14: U54.12 22.42,39.63 22.22,39.83 19.44,39.83 18.98,39.37 18.45,39.37 17.72,38.64 16.5,38.64 15.89,38.04 14.59,38.04 v1(14.1,37.55) ; J2.36 7.22,143.29 v1(6.97,143.55)
  L03_SIG01 w0.102: v1(14.1,37.55) 13,38.65 13,47.73 12.73,48.01 12.73,53.6 11.79,54.53 11.79,55.04 11.11,55.73 7.03,55.73 3.84,58.92 3.84,64.82 1.2,67.46 1.2,72.31 1.92,73.03 1.92,76.3 1,77.22 1,89.61 1.63,90.23 1.63,92.96 1.29,93.3 1.29,97.53 10.55,106.78 10.55,109.89 9.35,111.08 9.35,121.32 10.11,122.07 10.11,125 7.5,127.61 7.5,130.85 5.83,132.53 5.83,142.41 v1(6.97,143.55)
SOC_UART1_RX_BT: length 134.3
  TOP w0.14: v1(7.4,142.21) 7.94,141.67 7.94,140.89 9.03,139.79 J2.22 ; U54.15 18.99,38.21 17.82,37.04 16.82,37.04 16.43,36.66 v1(14.89,36.66)
  L03_SIG01 w0.102: v1(14.89,36.66) 14.5,37.05 14.5,38.19 13.3,39.38 13.3,47.72 13.56,47.98 13.56,54.04 10.86,56.75 6.48,56.75 4.1,59.12 4.1,64.88 1.43,67.55 1.43,72.21 2.15,72.93 2.15,76.45 1.23,77.38 1.23,89.52 1.86,90.14 1.86,93.06 1.52,93.39 1.52,97.43 10.95,106.86 10.95,110.68 12.25,111.98 12.25,118.91 10.38,120.78 10.38,125.08 7.73,127.72 7.73,130.95 6.08,132.6 6.08,138.91 7.4,140.23 v1(7.4,142.21)
SOC_UART1_RXD: length 39.8
  L03_SIG01 w0.102: v1(25.77,37.38) 25.71,37.38 25.41,37.08 25.41,31.12 26.57,29.96 26.57,19.69 27.05,19.21 27.05,18.4 27.43,18.01 27.43,11.82 26.32,10.71 26.32,8.52 28.83,6.01 30.26,6.01 30.95,6.69 v1(30.95,7.12)
  BOTTOM w0.14: TP72.1 31.43,6.63 v1(30.95,7.12) 30.95,7.12 30.95,7.4 30.69,7.66 U123.8 ; v1(25.77,37.38) 25.73,37.43 U95.3
SOC_UART1_TX_BT: length 134.2
  TOP w0.14: v1(14.9,37.54) 15.93,37.54 16.68,38.28 17.97,38.28 18.64,38.94 19.01,38.94 19.6,39.54 21.05,39.54 21.57,39.01 U54.13
  L03_SIG01 w0.102: v1(7.61,144.31) 7.61,142.93 7.88,142.67 7.88,140.25 6.31,138.68 6.31,132.69 7.96,131.04 7.96,127.87 10.6,125.23 10.6,120.9 12.52,118.98 12.52,111.01 11.3,109.78 11.3,106.89 1.75,97.34 1.75,93.68 2.08,93.35 2.08,90.05 1.82,89.78 1.82,88.09 2.03,87.88 2.03,83.94 1.46,83.38 1.46,79.03 3.21,77.28 3.21,72.21 2.4,71.41 2.4,66.9 4.36,64.95 4.36,59.33 6.55,57.13 10.93,57.13 13.81,54.25 13.81,39.42 14.9,38.34 v1(14.9,37.54)
  BOTTOM w0.14: R254.2 6.47,143.94 6.85,144.31 v1(7.61,144.31)
SOC_UART1_TXD: length 49.4
  L03_SIG01 w0.102: v1(33.34,10.35) 33.02,10.35 30.54,7.87 30.54,6.65 30.15,6.26 28.96,6.26 26.55,8.68 26.55,10.61 27.66,11.73 27.66,18.22 27.28,18.6 27.28,19.45 26.88,19.86 26.88,30.02 25.64,31.25 25.64,36.49 26.32,37.17 26.32,38.88 v1(25.78,39.42)
  BOTTOM w0.14: v1(25.78,39.42) 25.74,39.38 U95.6 ; U123.6 31.46,8.46 R570.2 32.2,8.11 32.7,8.62 32.7,9.71 v1(33.34,10.35) 33.31,10.38 TP71.1
SOC_USB0_DM: length 139.6
  TOP w0.102: v1(67.82,65.42) 67.82,65.16 69.05,63.93 69.05,54.31 68.26,53.52 68.26,42.19 67.4,41.33 67.4,38.76 66.37,37.73 63.44,37.73 60.49,34.78 56.87,34.78 56.14,34.05 40.76,34.05 39.99,33.28 36.95,33.28 35.12,31.45 34.26,31.45 30.95,28.14 30.95,26.56 28.93,24.54 20.12,24.54 17.37,27.29 17.37,28.76 16.28,29.84 15.24,29.84 15.14,29.74 15.14,29.62 15.03,29.52 L7.4 ; U18.AA10 v1(47.48,102.07)
  L03_SIG01 w0.102: v1(47.48,102.07) 47.72,101.82 48.06,101.82 48.32,101.56 49.72,101.56 50.14,101.14 50.14,100.13 51.62,98.65 51.62,98.11 53.52,96.2 53.52,91.05 55.96,88.61 57.86,88.61 60.06,86.4 60.06,85.77 60.83,85 61.93,85 62.92,84.01 62.92,73.09 65.59,70.42 65.59,68.24 66.75,67.07 66.75,66.08 67.41,65.42 v1(67.82,65.42)
SOC_USB0_DP: length 139.6
  TOP w0.102: v1(67.22,64.82) 67.46,65.05 67.63,65.05 68.84,63.84 68.84,54.4 68.05,53.61 68.05,42.27 67.19,41.42 67.19,38.85 66.28,37.94 63.35,37.94 60.4,34.99 56.78,34.99 56.05,34.26 40.68,34.26 39.91,33.49 36.86,33.49 35.03,31.66 34.17,31.66 30.74,28.23 30.74,26.65 28.84,24.75 20.2,24.75 17.58,27.38 17.58,28.84 16.37,30.05 15.24,30.05 15.14,30.16 15.14,30.27 15.03,30.37 L7.1 ; U18.AA9 v1(47.48,101.27)
  L03_SIG01 w0.102: v1(47.48,101.27) 47.48,101.52 47.58,101.62 47.98,101.62 48.24,101.36 49.64,101.36 49.94,101.06 49.94,100.04 51.41,98.57 51.41,98.02 53.32,96.12 53.32,90.96 55.88,88.4 57.77,88.4 59.86,86.32 59.86,85.68 60.74,84.8 61.84,84.8 62.72,83.93 62.72,73.01 65.38,70.34 65.38,68.15 66.55,66.99 66.55,65.99 67.4,65.14 67.4,65 v1(67.22,64.82)
SOC_USB0_DRVVBUS: length 94.9
  TOP w0.132: U18.C20 v1(32.28,110.86)
  L03_SIG01 w0.102: v1(32.28,110.86) 32.29,110.86 32.69,110.47 33.25,110.47 33.47,110.24 33.47,110.24 33.48,110.23 33.48,109.87 33.68,109.67 34.05,109.67 34.28,109.44 34.28,108.3 34.05,108.07 33.72,108.07 33.48,107.83 33.48,107.5 33.25,107.26 30.37,107.26 29.01,105.9 27.38,105.9 25.43,103.95 21.95,103.95 21.35,103.35 19.98,103.35 18.86,102.23 18.86,101.28 17.93,100.35 17.93,95.82 16.79,94.68 16.79,92.42 16.42,92.05 15.68,92.05 12.58,88.95 12.58,85.43 10.35,83.19 10.35,80.78 10.35,76.5 10.35,76.12 12.99,73.48 12.99,68.27 11.42,66.71 11.42,60.1 16.97,54.56 v1(16.97,50.94) 18.49,49.41 18.49,40.32 v1(18.82,39.99)
  BOTTOM w0.14: R446.1 v1(18.82,39.99) ; R416.1 v1(16.97,50.94)
SOC_USB0_RCALIB: length 4.4
  TOP w0.132: U18.W10 v1(45.88,102.07)
  BOTTOM w0.14: v1(45.88,102.07) 46.28,102.47 47.81,102.47 48.35,103.01 R331.1
SOC_USB0_VBUS: length 13.7
  TOP w0.356: U18.V8 v1(45.08,100.47)
  TOP w0.457: R134.1 52.2,75.14 v1(50.52,76.82)
  L07_PWR02 w0.165: 47.93,100.07 45.48,100.07 v1(45.08,100.47) 45.48,100.86 47.93,100.86
  BOTTOM w0.305: R338.1 45.2,100.59 v1(45.08,100.47)
SOC_USB1_DM: length 42.4
  TOP w0.102: L4.1 66.07,77.02 66.37,77.33 66.37,77.67 66.17,77.86 62.32,77.86 v1(62.08,77.62) ; U18.Y11 v1(46.68,102.87)
  L05_SIG02 w0.102: v1(46.68,102.87) 47.08,103.27 50.13,103.27 50.65,102.75 52.18,102.75 52.73,102.19 52.73,98.39 55.79,95.33 55.79,94.64 56.32,94.11 56.93,94.11 58.23,92.82 58.23,90.37 58.49,90.1 58.49,88.15 60.05,86.58 60.05,85.38 61.66,83.78 61.66,80.51 62.9,79.27 62.9,78.17 62.61,77.88 62.34,77.88 v1(62.08,77.62)
SOC_USB1_DP: length 42.7
  TOP w0.102: U18.Y10 v1(46.68,102.07) ; L4.4 66.92,77.02 66.58,77.36 66.58,77.76 66.26,78.08 62.34,78.08 v1(62.08,78.33)
  L05_SIG02 w0.102: v1(46.68,102.07) 46.68,102.36 46.79,102.47 47.78,102.47 47.89,102.58 47.89,102.96 47.99,103.07 50.05,103.07 50.57,102.55 52.09,102.55 52.53,102.11 52.53,98.31 55.59,95.24 55.59,94.56 56.24,93.91 56.85,93.91 58.02,92.73 58.02,90.28 58.29,90.02 58.29,88.06 59.85,86.5 59.85,85.3 61.45,83.7 61.45,80.43 62.7,79.18 62.7,78.25 62.53,78.08 62.34,78.08 v1(62.08,78.33)
