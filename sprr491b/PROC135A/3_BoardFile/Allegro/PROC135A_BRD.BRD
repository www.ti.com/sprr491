# Allegro board PROC135A_BRD.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
JTAG_EMU0: length 32.8
  TOP w0.14: J19.13 v1(36.08,11.49)
  L10_SIG03 w0.102: v1(36.08,11.49) 37.88,9.69 43.88,9.69 44.4,10.21 44.4,13.91 47.24,16.74 47.84,16.74 48.4,17.3 48.4,18.45 48.9,18.95 48.9,23.06 49.32,23.48 50.47,23.48 v1(51.21,24.22)
  BOTTOM w0.14: R564.2 v1(36.08,11.49) ; U106.7 49.34,24.97 49.64,25.28 50.24,25.28 50.57,24.94 50.98,24.94 51.21,24.72 v1(51.21,24.22)
JTAG_EMU1: length 29.5
  TOP w0.14: J19.14 v1(36.08,10.22)
  L05_SIG02 w0.102: v1(48.72,25.54) 48.31,25.13 47.34,25.13 47.06,25.41 43.06,25.41 40.95,23.31 38.46,23.31 36.4,21.25 36.4,16.38 36.74,16.04 36.74,10.76 36.2,10.22 v1(36.08,10.22)
  BOTTOM w0.14: R566.2 v1(36.08,10.22) ; v1(48.72,25.54) 48.72,25.52 48.99,25.25 U106.6
JTAG_EMU_RSTN: length 4.1
  TOP w0.14: J19.15 v1(34.81,15.38)
  BOTTOM w0.14: v1(34.81,15.38) 34.68,15.5 R552.2 34.23,15.99 33.76,16.46 U116.6
JTAG_TCK: length 9.1
  L10_SIG03 w0.102: v1(46.68,18.92) 46.73,18.92 47.89,20.08 47.89,21.97 46.97,22.9 v1(46.97,24.84)
  BOTTOM w0.14: U114.14 46.84,19.09 v1(46.68,18.92) 46.59,18.84 R528.1 ; R499.1 v1(46.97,24.84)
JTAG_TDI: length 10.3
  TOP w0.14: v1(47.94,17.7) 47.24,18.4 46.37,18.4 43.55,15.58 42.89,15.58 42.43,15.12 J19.3
  BOTTOM w0.14: R542.1 v1(47.94,17.7) 48.26,18.02 U114.12
JTAG_TDIS: length 2.7
  TOP w0.14: v1(42.7,10.31) 42.43,10.04 J19.4
  BOTTOM w0.14: R567.2 v1(42.7,10.31)
JTAG_TDO: length 4.7
  TOP w0.14: J19.7 v1(39.89,11.41)
  BOTTOM w0.14: v1(39.89,11.41) 40.2,11.41 41.13,10.48 U122.7
JTAG_TMS: length 8.4
  TOP w0.14: v1(47.07,17.93) 46.47,17.93 43.7,15.16 J19.1
  BOTTOM w0.14: R537.1 46.21,17.93 v1(47.07,17.93) 47.07,18.55 47.21,18.69 U114.13
JTAG_TRST#: length 14.4
  TOP w0.14: J19.2 v1(43.7,10.21)
  L10_SIG03 w0.102: v1(46.65,19.76) 45.58,18.69 45.58,15.72 44.11,14.25 44.11,10.62 v1(43.7,10.21)
  BOTTOM w0.14: U114.15 46.92,19.49 v1(46.65,19.76) R524.2
LDO_1V8: length 1.6
  TOP w0.14: v1(24.61,45.36) 24.44,45.19 C122.1
  BOTTOM w0.14: U90.35 v1(24.61,45.36)
LDO_3V3: length 96.4
  TOP w0.254: v1(65.61,62.12) 65.27,61.78 R146.1 ; v1(65.61,62.12) R142.1 ; v1(65.61,62.12) 65.94,61.78 65.94,60.26 R147.1 ; R145.1 v1(56.66,62.56) ; R161.1 R158.1 19.03,50.74 19.54,51.25 v1(20.2,51.25) ; v1(56.66,59.41) C105.1 U34.8 ; v1(16.74,74.22) U27.49
  TOP w0.381: C121.2 15.99,45.73 16.06,45.66 v1(16.18,45.66)
  L03_SIG01 w0.14: v1(16.74,74.22) 16.05,73.54 14.52,73.54 13.4,72.42 13.4,68.1 12.52,67.21 12.52,59.75 17.47,54.79 17.47,52.58 18.81,51.25 v1(20.2,51.25)
  L10_SIG03 w0.254: v1(24.75,50.81) 25.33,51.4 39.35,51.4 42.47,54.52 43.92,54.52 44.45,53.99 45.98,53.99 46.38,53.58 48.11,53.58 48.85,54.32 51.44,54.32 52.3,55.18 52.3,56.88 54.83,59.41 v1(56.66,59.41) 56.66,61.24 56.37,61.53 56.37,62.27 v1(56.66,62.56) 56.67,62.57 65.15,62.57 v1(65.61,62.12)
  BOTTOM w0.254: v1(20.2,51.25) 20.52,50.92 R412.1 ; R428.1 14.96,45.16 15.24,45.44 R425.1 15.97,45.44 v1(16.18,45.66) 16.28,45.76 U90.9 ; R419.1 v1(25.78,48.45) ; R415.1 R414.1 v1(24.75,50.81)
LINE1L+: length 2.4
  BOTTOM w0.254: C414.1 82.27,49.93 TP59.1
LINE1L+_C: length 2
  BOTTOM w0.254: U88.3 79.69,49.79 C414.2
LINE1R+: length 2.4
  BOTTOM w0.254: C416.1 82.27,48.66 TP60.1
LINE1R+_C: length 2
  BOTTOM w0.254: U88.5 79.69,48.79 C416.2
LO_LM5141: length 3.3
  BOTTOM w0.14: U89.8 33.53,48.32 32.61,49.24 R417.1
LOL_LM5141: length 2.9
  BOTTOM w0.14: U89.7 33.03,48.06 32.76,48.33 31.87,48.33 31.51,47.97 R418.1
LPDDR4_CA0: length 33.9
  TOP w0.305: U26.R2 v1(41.43,81.27) ; U18.J5 v1(37.08,98.07) ; U26.H2 v1(37.53,81.27)
  L03_SIG01 w0.076: v1(41.43,81.27) 41.43,80.81 41.33,80.71 41.04,80.71 40.96,80.79 40.96,80.91 40.88,80.99 40.57,80.99 40.36,80.78 39.97,80.78 39.88,80.87 v1(39.48,80.87) 39.08,80.87 38.99,80.78 38.6,80.78 38.39,80.99 38.08,80.99 38,80.91 38,80.79 37.92,80.71 37.63,80.71 37.53,80.81 v1(37.53,81.27)
  L10_SIG03 w0.165: v1(37.08,98.07) 37.08,97.84 36.68,97.44 36.68,97.06 36.49,96.86 36.11,96.86 35.88,96.63 35.88,96.3 35.65,96.07 35.31,96.07 35.08,95.83 35.08,95.46 34.88,95.27 33.69,95.27 33.48,95.06 33.48,94.7
  L10_SIG03 w0.203: v1(39.48,80.87) 39.44,80.82 38.61,80.82 38.18,81.26 38.18,81.34 37.51,82.01 37.51,83.66 36.94,84.23 33.12,84.23 32.84,84.51 32.84,84.82 31.38,86.27 31.38,91.71 31.71,92.04 31.71,92.8 33.48,94.57 33.48,94.7
LPDDR4_CA1: length 33.9
  TOP w0.305: U26.P2 v1(40.78,82.07) ; U18.J2 v1(37.08,95.67) ; U26.J2 v1(38.18,82.07)
  L03_SIG01 w0.076: v1(38.18,82.07) 37.94,81.83 37.94,81.67 38.03,81.59 38.53,81.59 38.64,81.69 38.64,81.99 38.72,82.07 38.98,82.07 39.06,81.99 39.06,81.75 39.14,81.67 v1(39.48,81.67) 39.82,81.67 39.91,81.75 39.91,81.99 39.98,82.07 40.24,82.07 40.32,81.99 40.32,81.69 40.43,81.59 40.93,81.59 41.02,81.67 41.02,81.83 v1(40.78,82.07)
  L10_SIG03 w0.165: 38.71,83.96 38.71,83.5 38.61,83.4 38.61,82.33 38.82,82.13
  L10_SIG03 w0.203: 38.82,82.13 38.98,81.96 39.18,81.96 v1(39.48,81.67) ; v1(37.08,95.67) 36.61,95.19 36.22,95.19 36,94.98 36,94.74 35.7,94.43 34.21,94.43 32.37,92.59 32.37,91.88 31.89,91.4 31.89,88.13 32.09,87.93 32.33,87.93 32.53,87.72 32.53,87.38 32.32,87.17 32.05,87.17 31.89,87.01 31.89,86.57 32.5,85.97 32.78,85.97 33.45,86.63 33.82,86.63 34.05,86.4 34.05,85.89 33.6,85.44 33.6,85.08 33.81,84.88 34.16,84.88 34.62,85.34 35.57,85.34 35.8,85.12 36.31,85.12 36.42,85.23 36.8,85.23 36.98,85.04 38.46,85.04 38.71,84.8 38.71,83.96
LPDDR4_CA2: length 33.9
  TOP w0.305: U26.R9 v1(42.08,86.86) ; U18.J4 v1(37.88,98.07) ; U26.H9 v1(36.88,86.86)
  L03_SIG01 w0.076: v1(42.08,86.86) 41.71,87.23 v1(39.48,87.23) 37.25,87.23 v1(36.88,86.86)
  L10_SIG03 w0.165: 33.29,88.95 33.38,88.86 35.77,88.86 35.99,88.64 35.99,88.23 35.83,88.06 34.7,88.06 ; 37.48,95.44 U18.J4 v1(37.88,98.07)
  L10_SIG03 w0.203: v1(39.48,87.23) 39.03,87.23 38.77,86.97 38.77,85.84 38.46,85.53 37.27,85.53 37,85.8 37,86.04 36.75,86.29 36.51,86.29 36.35,86.45 35.85,86.45 35.68,86.29 35.02,86.29 34.83,86.47 34.83,87.12 34.61,87.34 34.24,87.34 34.1,87.48 34.1,87.87 34.27,88.05 34.68,88.05 34.7,88.06 ; 33.29,88.95 33.25,88.99 32.67,88.99 32.46,89.2 32.46,91.11 32.99,91.63 32.99,92.39 34.54,93.95 36.05,93.95 37.48,95.38 37.48,95.44
LPDDR4_CA3: length 33.9
  TOP w0.305: U18.L4 v1(38.68,97.27) ; U26.R10 v1(41.43,87.67) ; U26.H10 v1(37.53,87.67)
  L03_SIG01 w0.076: v1(37.53,87.67) 37.53,87.96 37.61,88.03 38.5,88.03 38.6,87.93 38.6,87.71 38.69,87.62 38.94,87.62 39.02,87.7 39.02,87.81 39.1,87.89 v1(39.48,87.89) 39.86,87.89 39.94,87.81 39.94,87.7 40.02,87.62 40.27,87.62 40.36,87.71 40.36,87.93 40.47,88.03 41.35,88.03 41.43,87.96 v1(41.43,87.67)
  L10_SIG03 w0.165: 40.01,96.87 40.51,96.87 40.68,96.69 40.68,96.24 40.85,96.07 43.68,96.07 43.88,95.86 43.88,95.43 ; 39.96,89.66 39.73,89.43 39.73,89.1 39.88,88.95 39.88,88.62 39.88,88.61 39.48,88.21 v1(39.48,87.89)
  L10_SIG03 w0.203: v1(38.68,97.27) 38.99,97.57 39.55,97.57 39.76,97.37 39.76,97.11 40.01,96.87 ; 39.96,89.66 40.01,89.71 40.01,92.19 39.78,92.42 39.78,92.61 39.4,93 39.4,95.08 39.14,95.34 39.14,96.36 39.31,96.53 39.62,96.53 39.83,96.33 39.83,95.43 40.04,95.21 40.41,95.21 40.65,94.97 40.65,94.61 40.86,94.41 41.35,94.41 41.53,94.59 41.53,95.04 41.74,95.24 42.36,95.24 42.57,95.04 42.57,94.28 42.78,94.06 43.94,94.06 44.32,94.45 44.72,94.45 44.86,94.59 44.86,94.92 44.68,95.11 44.08,95.11 43.88,95.31 43.88,95.43
LPDDR4_CA4: length 33.9
  TOP w0.305: U26.R11 v1(41.43,88.46) ; U26.H11 v1(37.53,88.46) ; U18.J1 v1(37.88,94.87)
  L03_SIG01 w0.076: v1(41.43,88.46) 41.43,88.76 41.35,88.83 41.03,88.83 40.94,88.74 40.94,88.55 40.85,88.46 40.63,88.46 40.53,88.56 40.53,88.7 40.45,88.78 v1(39.48,88.78) 38.51,88.78 38.43,88.7 38.43,88.56 38.33,88.46 38.11,88.46 38.02,88.55 38.02,88.74 37.93,88.83 37.61,88.83 37.53,88.76 v1(37.53,88.46)
  L10_SIG03 w0.203: v1(37.88,94.87) 37.66,94.65 37.49,94.65 36.98,94.14 36.98,92.7 36.87,92.58 36.58,92.58 36.45,92.71 36.45,93.23 36.25,93.43 35.51,93.43 35.16,93.08 34.94,93.08 34.82,93.2 34.6,93.2 34.44,93.04 34.44,92.82 34.56,92.71 34.56,92.49 34.4,92.33 34.18,92.33 34.07,92.44 33.85,92.44 33.69,92.29 33.69,92.07 33.8,91.95 33.8,91.73 33.05,90.97 33.05,89.94 33.25,89.73 33.8,89.73 34.16,89.37 34.37,89.37 34.54,89.54 34.54,89.76 34.08,90.22 34.08,90.55 33.87,90.76 33.87,91 35.26,92.39 35.56,92.39 35.75,92.2 35.75,91.97 34.82,91.03 34.82,90.71 35.13,90.4 35.13,90.01 35.28,89.85 35.86,89.85 36,89.71 36,89.23 36.09,89.14 36.35,89.14 36.46,89.25 36.46,89.87 36.61,90.02 36.83,90.02 37.02,89.83 38.21,89.83 38.4,89.64 38.4,89.35 38,88.94 38,88.73 38.18,88.54 38.4,88.54 38.64,88.78 v1(39.48,88.78)
LPDDR4_CA5: length 33.9
  TOP w0.305: U26.J11 v1(37.53,89.26) ; U26.P11 v1(41.43,89.26) ; U18.K5 v1(38.68,98.07)
  L03_SIG01 w0.076: v1(41.43,89.26) 41.17,89.53 41.01,89.53 40.93,89.45 40.93,89.22 40.86,89.15 40.63,89.15 40.55,89.23 40.55,89.5 40.3,89.75 v1(39.48,89.75) 38.66,89.75 38.41,89.5 38.41,89.23 38.33,89.15 38.1,89.15 38.03,89.22 38.03,89.45 37.95,89.53 37.79,89.53 v1(37.53,89.26)
  L10_SIG03 w0.165: 38.28,95.5 38.28,98.29 38.1,98.47 37.72,98.47 37.6,98.6 37.6,98.77 37.72,98.9
  L10_SIG03 w0.203: v1(38.68,98.07) 38.83,98.21 38.83,98.5 38.43,98.9 37.72,98.9 ; v1(39.48,89.75) 39.22,90.01 39.22,90.42 39.47,90.68 39.47,92.02 39.35,92.14 39.05,92.14 38.92,92.01 38.92,90.9 38.77,90.76 38.55,90.76 38.4,90.9 38.4,92.03 38.29,92.14 37.99,92.14 37.87,92.02 37.87,90.82 37.73,90.68 37.5,90.68 37.34,90.84 37.34,91.35 37.19,91.49 36.74,91.49 36.62,91.37 36.62,91.12 36.8,90.94 36.8,90.69 36.69,90.57 36.4,90.57 36.24,90.72 36.06,90.72 35.84,90.94 35.84,91.37 36.52,92.05 37.14,92.05 37.5,92.41 37.5,92.89 37.65,93.04 38.7,93.04 38.85,93.19 38.85,93.46 38.7,93.6 37.71,93.6 37.57,93.73 37.57,94.01 37.73,94.16 38.7,94.16 38.85,94.31 38.85,94.52 38.71,94.65 38.52,94.65 38.38,94.79 38.38,95.15 38.28,95.26 38.28,95.5
LPDDR4_CAL0: length 5
  TOP w0.132: U18.H6 v1(36.28,98.87)
  BOTTOM w0.14: R349.1 35.88,95.36 35.88,98.47 v1(36.28,98.87)
LPDDR4_CK_N: length 33.9
  TOP w0.305: U26.P9 v1(40.78,86.86) ; U18.L1 39.27,95.07 39.27,93.93 39.87,93.33 v1(39.88,93.33) ; U26.J9 v1(38.18,86.86)
  L03_SIG01 w0.076: v1(38.18,86.86) 38.18,86.76 38.3,86.64 38.73,86.64 38.96,86.41 38.96,86.01 38.86,85.91 38.86,85.64 38.98,85.51 39.19,85.51 39.27,85.59 39.27,85.72 v1(39.48,85.93) 39.69,85.72 39.69,85.59 39.77,85.51 39.98,85.51 40.1,85.63 40.1,85.91 40,86.01 40,86.4 40.24,86.64 40.66,86.64 40.78,86.76 v1(40.78,86.86)
  L10_SIG03 w0.188: v1(39.88,93.33) 40.13,93.58 40.64,93.58 41.05,93.17 42.79,93.17 42.98,92.98 42.98,92.72 42.79,92.52 42.79,92.01 43.15,91.64 43.7,91.64 43.98,91.93 44.25,91.93 44.56,91.61 45.09,91.61 45.31,91.83 45.61,91.83 45.99,91.44 45.99,89.96 45.79,89.76 45.25,89.76 45.04,89.96 45.04,90.65 44.68,91.01 42.66,91.01 41.94,91.74 41.94,92.26 41.57,92.62 40.9,92.62 40.52,92.24 40.52,91.44 41.02,90.94 41.02,90.02 40.57,89.57 40.57,88.01 39.97,87.41 39.97,85.89 39.8,85.72 39.67,85.72 39.48,85.91 v1(39.48,85.93)
LPDDR4_CK_P: length 34
  TOP w0.305: U26.P8 v1(40.78,86.06) ; v1(39.9,94.04) 39.69,94.25 39.69,95.07 U18.M1 ; U26.J8 v1(38.18,86.06)
  L03_SIG01 w0.076: v1(40.78,86.06) 40.86,86.15 40.86,86.33 40.79,86.4 40.34,86.4 40.24,86.3 40.24,86.11 40.34,86.01 40.34,85.53 40.08,85.27 v1(39.48,85.27) 38.88,85.27 38.62,85.54 38.62,86.01 38.72,86.11 38.72,86.31 38.63,86.4 38.17,86.4 38.1,86.33 38.1,86.15 v1(38.18,86.06)
  L10_SIG03 w0.188: v1(39.9,94.04) 40.06,93.88 40.77,93.88 41.17,93.47 42.92,93.47 43.28,93.11 43.28,92.59 43.09,92.4 43.09,92.13 43.27,91.94 43.57,91.94 43.86,92.23 44.37,92.23 44.69,91.91 44.97,91.91 45.18,92.13 45.73,92.13 46.29,91.57 46.29,89.84 45.91,89.46 45.12,89.46 44.74,89.84 44.74,90.52 44.55,90.71 42.54,90.71 41.64,91.61 41.64,92.14 41.45,92.32 41.03,92.32 40.82,92.12 40.82,91.56 41.32,91.06 41.32,89.9 40.87,89.45 40.87,87.89 40.27,87.29 40.27,85.77 39.92,85.42 39.63,85.42 v1(39.48,85.27)
LPDDR4_CKE0: length 33.9
  TOP w0.305: U26.P4 v1(40.78,83.67) ; U26.J4 v1(38.18,83.67) ; U18.P3 v1(41.08,96.47)
  L03_SIG01 w0.076: v1(38.18,83.67) 37.81,83.67 37.72,83.75 37.72,83.97 37.82,84.06 38.59,84.06 38.7,83.95 38.7,83.78 38.81,83.67 v1(39.48,83.67) 40.15,83.67 40.26,83.78 40.26,83.95 40.37,84.06 41.14,84.06 41.24,83.97 41.24,83.75 41.15,83.67 v1(40.78,83.67)
  L10_SIG03 w0.165: 45.48,95.51 45.48,95.83 45.25,96.07 45.23,96.07 44.85,96.07 44.68,96.23 44.68,96.66 44.48,96.87 41.48,96.87 v1(41.08,96.47)
  L10_SIG03 w0.203: v1(39.48,83.67) 39.47,83.67 39.06,84.09 39.06,84.64 39.26,84.84 39.87,84.84 40.56,85.53 41.75,85.53 41.96,85.74 41.96,86.06 42.16,86.26 42.38,86.26 42.6,86.48 42.6,86.93 43.02,87.35 43.44,87.35 43.58,87.49 43.58,87.87 43.18,88.27 43.18,88.63 43.32,88.77 43.62,88.77 43.91,89.06 44.23,89.06 44.59,88.7 44.59,88.27 44.75,88.12 45.27,88.12 45.39,88.24 45.39,88.69 45.6,88.89 46.81,88.89 47.02,89.1 47.02,91.84 46.13,92.72 46.13,94.1 45.93,94.3 45.62,94.3 45.35,94.57 45.35,95.05 45.48,95.18 45.48,95.51
LPDDR4_CKE1: length 33.9
  TOP w0.305: U26.P5 v1(40.78,84.47) ; U18.P5 v1(41.08,98.07) ; U26.J5 v1(38.18,84.47)
  L03_SIG01 w0.076: v1(38.18,84.47) 37.85,84.8 37.85,84.98 37.95,85.08 38.47,85.08 38.8,84.75 38.8,84.51 38.9,84.41 v1(39.48,84.41) 40.06,84.41 40.16,84.51 40.16,84.75 40.49,85.08 41.01,85.08 41.11,84.98 41.11,84.8 v1(40.78,84.47)
  L10_SIG03 w0.165: v1(41.08,98.07) 41.48,97.67 44.45,97.67 44.68,97.43 44.68,97.1 44.91,96.87 45.25,96.87 45.48,96.63 45.48,96.63 45.48,96.3 45.71,96.07 46.07,96.07 46.28,95.85 46.28,95.42
  L10_SIG03 w0.203: 46.28,95.42 46.73,94.97 46.73,92.85 47.6,91.98 47.6,87.87 47.36,87.63 46.87,87.63 46.66,87.43 46.66,87.14 46.86,86.95 47.32,86.95 47.51,86.76 47.51,86.11 46.68,85.28 42.63,85.28 42.43,85.08 40.66,85.08 39.99,84.41 v1(39.48,84.41)
LPDDR4_CS0_A: length 28.4
  TOP w0.305: U18.J6 v1(37.08,98.87) ; U26.H4 v1(36.88,83.67)
  L10_SIG03 w0.165: 32.68,94.66 32.68,95.03 32.91,95.26 33.25,95.26 33.48,95.5 33.48,95.83 33.71,96.07 34.87,96.07 35.08,96.28 35.08,96.63 35.31,96.86 35.65,96.86 35.88,97.1 35.88,97.46 36.09,97.67 36.45,97.67 36.68,97.9 36.68,98.24 37.08,98.64 v1(37.08,98.87) ; 33.42,83.27 33.91,83.27 34.05,83.41 34.05,83.68 34.16,83.79 34.4,83.79 34.51,83.68 34.51,83.41 34.65,83.27 35.26,83.27 35.35,83.17 35.35,83 35.47,82.88 35.7,82.88 35.81,82.99 35.81,83.17 35.91,83.27 36.72,83.27 36.88,83.43 v1(36.88,83.67)
  L10_SIG03 w0.203: 32.68,94.66 32.68,94.59 31.2,93.12 31.2,92.3 30.87,91.97 30.87,85.37 30.99,85.26 31.19,85.26 31.3,85.38 31.59,85.38 31.8,85.17 31.8,84.95 31.66,84.81 31.47,84.81 31.34,84.68 31.34,84.39 31.58,84.16 32.5,84.16 32.79,83.87 32.79,83.52 32.95,83.37 33.25,83.37 33.35,83.27 33.42,83.27
LPDDR4_CS0_B: length 28.9
  TOP w0.305: U26.R4 v1(41.43,82.87) ; U18.M6 v1(40.28,98.87)
  L10_SIG03 w0.165: 47.88,94.62 47.88,95.08 47.69,95.26 47.31,95.26 47.08,95.5 47.08,95.83 46.85,96.07 46.51,96.07 46.28,96.3 46.28,96.63 46.05,96.86 45.71,96.86 45.48,97.1 45.48,97.43 45.25,97.67 44.91,97.67 44.68,97.9 44.68,98.23 44.45,98.47 44.4,98.47 40.68,98.47 v1(40.28,98.87)
  L10_SIG03 w0.203: 47.88,94.62 47.88,94.41 47.76,94.29 47.76,92.54 48.11,92.19 48.11,85.82 46.41,84.12 41.85,84.12 41.43,83.7 v1(41.43,82.87)
LPDDR4_CS1_A: length 32.6
  TOP w0.305: U18.N4 v1(41.08,97.27) ; U26.H3 v1(36.88,82.87)
  L10_SIG03 w0.165: v1(41.08,97.27) U18.N4 40.08,97.67 39.41,98.34 39.41,98.5 38.65,99.26 36.91,99.26 36.68,99.03 36.68,98.67 36.47,98.47 36.11,98.47 35.88,98.23 35.88,97.89 35.66,97.67 35.3,97.67 35.08,97.44 35.08,97.09 34.85,96.87 33.71,96.87 33.48,96.64 33.48,96.33 33.48,96.3 33.25,96.07 32.91,96.07 32.68,95.83 32.68,95.48 32.46,95.27 32.1,95.27 31.88,95.05 31.88,94.72 ; 33.35,82.47 36.48,82.47 36.88,82.86 v1(36.88,82.87)
  L10_SIG03 w0.203: 33.35,82.47 33.23,82.58 32.81,82.58 32.09,83.31 31.67,83.31 30.36,84.62 30.36,92.33 30.69,92.65 30.69,93.36 31.88,94.55 31.88,94.72
LPDDR4_CS1_B: length 32.5
  TOP w0.305: U26.R3 v1(41.43,82.07) ; U18.M5 v1(40.28,98.07)
  L10_SIG03 w0.165: 48.46,95.26 48.11,95.26 47.88,95.5 47.88,95.83 47.65,96.07 47.64,96.07 47.31,96.07 47.08,96.3 47.08,96.63 46.85,96.87 46.51,96.87 46.28,97.1 46.28,97.43 46.05,97.66 45.71,97.66 45.48,97.9 45.48,98.25 45.27,98.47 44.91,98.47 44.68,98.7 44.68,99.05 44.47,99.26 40.1,99.26 39.88,99.05 39.88,98.43 40.25,98.07 v1(40.28,98.07) ; v1(41.43,82.07) 41.43,82.07 41.83,82.47 41.83,82.64 42.46,83.27 46.17,83.27
  L10_SIG03 w0.203: 46.17,83.27 46.32,83.27 48.61,85.56 48.61,92.41 48.27,92.76 48.27,94.08 48.72,94.53 48.72,95.06 48.52,95.26 48.46,95.26
LPDDR4_DMI0: length 25.7
  TOP w0.267: U18.C2 v1(32.28,95.67) ; U26.C3 v1(33.63,82.07)
  L05_SIG02 w0.14: v1(33.63,82.07) 33.23,82.47 32.09,82.47 31.79,82.17 31.5,82.17 31.37,82.3 30.91,82.3 30.79,82.17 29.93,82.17 27.16,84.95 27.16,94.43 29.71,96.99 30.35,96.99 30.47,96.87 31.68,96.87 31.88,96.66 31.88,96.07 v1(32.28,95.67)
LPDDR4_DMI1: length 16.4
  TOP w0.267: U18.F3 v1(34.68,96.47) ; U26.C10 v1(33.63,88.47)
  L03_SIG01 w0.14: v1(34.68,96.47) 34.42,96.47 34.28,96.33 34.28,95.4 34.14,95.26 33.71,95.26 33.48,95.03 33.48,94.65 33.28,94.45 33.03,94.45 31.92,93.34 31.92,91.8 31.8,91.68 31.47,91.68 31.07,91.27 31.07,90.49 31.21,90.35 31.46,90.35 31.57,90.47 31.57,91.17 31.69,91.28 31.83,91.28 31.96,91.16 31.96,90.06 32.05,89.96 32.05,89 32.18,88.88 32.38,88.88 32.51,89.01 32.51,89.57 32.62,89.68 32.82,89.68 32.93,89.56 32.93,89.03 33.07,88.89 33.21,88.89 v1(33.63,88.47)
LPDDR4_DMI2: length 25.3
  TOP w0.267: U18.U1 43.88,94.64 v1(43.84,94.6) ; U26.Y3 v1(44.68,82.87)
  L05_SIG02 w0.14: v1(44.68,82.87) 45.28,83.46 45.28,83.77 45.74,84.23 46.55,84.23 47.4,85.09 47.4,88.79 45.95,90.24 45.95,90.6 44.84,91.72 42.76,91.72 42.27,92.21 42.27,92.89 42.68,93.3 42.68,94.35 42.28,94.75 42.28,97.52 42.43,97.67 42.92,97.67 43.08,97.5 43.08,95.36 v1(43.84,94.6)
LPDDR4_DMI3: length 19.6
  TOP w0.267: U26.Y10 v1(45.33,87.67) ; U18.W3 v1(45.88,96.47)
  L03_SIG01 w0.14: v1(45.33,87.67) 45.73,88.07 46.23,88.07 46.98,88.81 47.76,88.81 48.81,89.86 48.81,90.06 48.54,90.32 48.54,90.52 48.68,90.65 48.88,90.65 49.14,90.39 49.34,90.39 49.47,90.52 49.47,91.11 49.33,91.25 49.09,91.25 48.69,91.66 48.49,91.66 48.35,91.52 48.35,91.31 48.25,91.21 47.98,91.21 47.88,91.32 47.88,91.79 48.03,91.94 48.03,92.21 47.88,92.36 47.88,95.1 48.05,95.26 49.14,95.26 49.3,95.43 49.3,95.66 48.9,96.07 46.28,96.07 v1(45.88,96.47)
LPDDR4_DQ0: length 25.7
  TOP w0.267: U18.A5 v1(30.68,98.07) ; U26.B2 v1(32.98,81.27)
  L05_SIG02 w0.14: v1(30.68,98.07) 28.57,98.07 27.78,97.27 27.78,96.24 26.32,94.78 26.32,84.6 29.68,81.23 32.29,81.23 32.32,81.27 v1(32.98,81.27)
LPDDR4_DQ1: length 25.7
  TOP w0.267: U26.C2 v1(33.63,81.27) ; U18.B4 v1(31.48,97.27)
  L05_SIG02 w0.14: v1(33.63,81.27) 33.23,81.67 29.84,81.67 26.74,84.77 26.74,94.61 28.21,96.08 28.21,96.48 28.41,96.69 28.59,96.69 29.47,97.56 30.35,97.56 30.45,97.66 31.08,97.66 v1(31.48,97.27)
LPDDR4_DQ2: length 25.7
  TOP w0.267: U18.B6 v1(31.48,98.87) ; U26.E2 v1(34.93,81.27)
  L05_SIG02 w0.14: v1(34.93,81.27) 35.33,81.67 36.09,81.67 36.34,81.92 36.34,82.25 36.56,82.46 37.1,82.46 37.29,82.65 37.29,83.82 37.04,84.07 36.64,84.07 36.29,84.42 36.29,85.16 36.18,85.27 36.18,86.08 36,86.26 35.28,86.26 35.07,86.47 35.07,87.03 35.3,87.27 35.82,87.27 35.99,87.43 35.99,89.57 34.86,90.69 34.86,91.21 35.08,91.43 35.08,95.83 34.85,96.07 34.51,96.07 34.28,96.3 34.28,96.63 34.05,96.87 33.71,96.87 33.48,97.1 33.48,97.46 33.27,97.67 32.91,97.67 32.68,97.9 32.68,98.26 32.47,98.47 31.88,98.47 v1(31.48,98.87)
LPDDR4_DQ3: length 25.7
  TOP w0.267: U18.D5 v1(33.08,98.07) ; U26.F2 v1(35.58,81.27)
  L05_SIG02 w0.14: v1(33.08,98.07) 33.56,98.55 34.14,98.55 34.28,98.41 34.28,97.8 34.42,97.67 34.88,97.67 35.08,97.47 35.08,97.07 35.28,96.86 35.65,96.86 35.88,96.63 35.88,93.35 35.61,93.07 35.61,92.26 35.75,92.12 36.17,92.12 36.31,91.97 36.31,91.78 36.17,91.63 35.79,91.63 35.65,91.49 35.65,91.21 35.79,91.07 36.29,91.07 36.45,90.91 36.45,87.22 36.33,87.11 36.33,86.61 36.6,86.34 36.74,86.34 37.02,86.07 37.02,85.78 37.22,85.57 37.22,85.26 37.09,85.13 37.09,84.46 37.33,84.22 37.53,84.22 37.68,84.07 37.68,82.12 37.36,81.8 37.2,81.8 36.78,81.38 36.78,81 36.64,80.86 35.98,80.86 v1(35.58,81.27)
LPDDR4_DQ4: length 25.7
  TOP w0.267: U26.F4 v1(36.23,83.67) ; U18.C5 v1(32.28,98.07)
  L05_SIG02 w0.14: v1(32.28,98.07) 32.28,97.78 32.42,97.64 32.54,97.64 32.68,97.5 32.68,97.04 32.86,96.87 33.21,96.87 33.25,96.86 33.48,96.63 33.48,96.3 33.71,96.07 34.05,96.07 34.28,95.83 34.28,95.29 34.55,95.02 34.55,92.42 34.2,92.07 34.2,91.88 34.43,91.64 34.43,91.45 34.29,91.31 34.1,91.31 33.87,91.54 33.67,91.54 33.53,91.4 33.53,91.21 33.77,90.98 33.77,90.78 33.63,90.65 33.43,90.65 33.2,90.88 33.01,90.88 32.59,90.47 32.59,90.27 33.14,89.72 33.14,89.53 33.01,89.39 32.81,89.39 32.26,89.94 32.07,89.94 31.9,89.77 31.9,88.21 32.18,87.93 32.18,87.56 31.9,87.28 31.9,86.91 32.14,86.66 32.14,86.26 31.9,86.01 31.9,85.67 32.12,85.44 34.94,85.44 35.25,85.14 35.25,84.52 35.57,84.2 35.95,84.2 36.23,83.93 v1(36.23,83.67)
LPDDR4_DQ5: length 25.7
  TOP w0.267: U18.C3 v1(32.28,96.47) ; U26.E4 v1(35.58,83.67)
  L05_SIG02 w0.14: v1(35.58,83.67) 35.57,83.67 34.99,84.25 34.45,84.25 34.18,84.51 34.18,84.92 34.02,85.09 31.46,85.09 31.2,85.34 31.2,85.82 31.46,86.07 31.46,90.11 31.84,90.49 31.84,90.69 31.36,91.17 31.36,91.36 31.5,91.5 31.69,91.5 32.17,91.02 32.37,91.02 32.51,91.16 32.51,91.35 32.02,91.84 32.02,92.03 32.16,92.17 32.36,92.17 32.84,91.68 33.03,91.68 33.27,91.92 33.27,92.11 32.84,92.54 32.84,92.73 32.98,92.87 33.17,92.87 33.6,92.44 33.79,92.44 34.1,92.75 34.1,93.21 33.93,93.38 33.55,93.38 33.41,93.52 33.41,93.76 33.51,93.86 33.95,93.86 34.09,94 34.09,94.24 33.95,94.38 33.62,94.38 33.48,94.52 33.48,95.83 33.25,96.07 32.68,96.07 v1(32.28,96.47)
LPDDR4_DQ6: length 25.7
  TOP w0.267: U26.C4 v1(33.63,82.86) ; U18.B2 v1(31.48,95.67)
  L05_SIG02 w0.14: v1(33.63,82.86) 33.11,83.38 32.75,83.38 32.63,83.27 32.13,83.27 31.84,83.55 30.78,83.55 28.53,85.79 28.14,85.79 28.01,85.93 28.01,86.43 28.16,86.58 28.72,86.58 28.87,86.73 28.87,86.95 28.72,87.1 28.16,87.1 28.01,87.25 28.01,87.53 28.16,87.68 28.77,87.68 28.91,87.82 28.91,88.04 28.74,88.2 28.16,88.2 28.01,88.36 28.01,88.57 28.16,88.72 28.77,88.72 28.91,88.87 28.91,89.08 28.74,89.25 28.16,89.25 28.01,89.4 28.01,89.61 28.16,89.77 28.77,89.77 28.91,89.91 28.91,90.12 28.74,90.29 28.16,90.29 28.01,90.44 28.01,90.68 28.19,90.86 28.63,90.86 28.77,91 28.77,91.45 29,91.68 29.79,91.68 30.7,92.59 30.7,93.98 31.08,94.36 31.08,95.27 v1(31.48,95.67)
LPDDR4_DQ7: length 25.7
  TOP w0.267: v1(31.89,82.86) 32.91,82.86 U26.B4 ; v1(30.27,96.47) 30.68,96.47 U18.A3
  L05_SIG02 w0.14: v1(31.89,82.86) 30.82,82.86 30.63,82.68 30.09,82.68 29.95,82.82 29.95,83.02 30.15,83.22 30.15,83.43 29.94,83.64 29.74,83.64 29.57,83.47 29.33,83.47 28.93,83.86 28.93,84.09 28.76,84.27 28.53,84.27 28.37,84.42 28.37,84.64 28.57,84.84 28.57,85.06 28.42,85.21 28.21,85.21 28,85 27.79,85 27.57,85.22 27.57,91.17 27.71,91.31 28.12,91.31 28.26,91.45 28.26,91.86 28.11,92 27.71,92 27.57,92.14 27.57,94.26 28.21,94.9 28.88,94.9 29.05,95.06 29.05,95.61 29.2,95.77 29.54,95.77 29.71,95.6 29.71,95.01 29.85,94.87 30.05,94.87 30.2,95.02 30.2,95.99 30.27,96.06 v1(30.27,96.47)
LPDDR4_DQ8: length 16.3
  TOP w0.267: U26.B11 v1(32.98,88.47) ; U18.E2 v1(33.88,95.67)
  L03_SIG01 w0.14: v1(33.88,95.67) 33.65,95.67 33.25,95.27 32.92,95.27 32.68,95.03 32.68,94.7 31.5,93.52 31.5,92.3 30.6,91.41 30.6,88.26 30.74,88.12 31.09,88.12 31.23,88.26 31.23,89.79 31.35,89.91 31.52,89.91 31.63,89.79 31.63,88.04 31.77,87.9 32.41,87.9 v1(32.98,88.47)
LPDDR4_DQ9: length 16.4
  TOP w0.267: U18.F5 v1(34.68,98.07) ; U26.C11 v1(33.63,89.27)
  L03_SIG01 w0.14: v1(33.63,89.27) 33.33,89.57 33.33,89.7 32.88,90.15 32.59,90.15 32.38,90.35 32.38,93.18 33.21,94 33.42,94 33.83,94.41 34.19,94.41 34.48,94.7 34.48,94.87 35.08,95.47 35.08,96.64 34.85,96.87 34.49,96.87 34.28,97.08 34.28,97.49 34.1,97.67 32.88,97.67 32.68,97.87 32.68,98.27 32.87,98.47 34.19,98.47 34.59,98.07 v1(34.68,98.07)
LPDDR4_DQ10: length 16.4
  TOP w0.267: U18.E6 v1(34.68,98.87) ; U26.E11 v1(34.93,89.26)
  L03_SIG01 w0.14: v1(34.93,89.26) 34.71,89.49 34.71,89.69 35.08,90.06 35.08,90.51 34.8,90.79 34.8,93.03 35,93.23 36.08,93.23 36.22,93.37 36.22,95.14 35.88,95.49 35.88,97.51 35.73,97.67 35.22,97.67 35.08,97.81 35.08,99.12 34.94,99.27 33.62,99.27 33.52,99.16 33.52,98.97 33.62,98.87 v1(34.68,98.87)
LPDDR4_DQ11: length 16.4
  TOP w0.267: U18.G2 v1(36.28,96.47) ; U26.F11 v1(35.58,89.26)
  L03_SIG01 w0.14: v1(35.58,89.26) 35.58,89.54 35.72,89.68 35.72,89.87 35.44,90.15 35.44,90.41 35.93,90.9 35.93,91.14 35.79,91.28 35.38,91.28 35.22,91.44 35.22,92.7 35.32,92.8 35.51,92.8 35.61,92.7 35.61,91.76 35.71,91.66 35.93,91.66 36.05,91.77 36.05,92.15 36.13,92.23 36.32,92.23 36.42,92.13 36.42,91.5 36.3,91.38 36.3,91.01 36.44,90.88 36.6,90.88 36.71,90.98 36.71,91.12 36.82,91.24 36.82,92.38 36.5,92.7 36.5,92.98 36.65,93.13 36.65,93.4 36.94,93.69 36.94,93.94 36.65,94.22 36.65,94.49 36.93,94.77 36.93,95.11 36.68,95.36 36.68,96.33 36.54,96.47 v1(36.28,96.47)
LPDDR4_DQ12: length 16.4
  TOP w0.267: U18.G6 v1(35.48,98.87) ; U26.F9 v1(35.58,86.87)
  L03_SIG01 w0.14: v1(35.48,98.87) 35.88,98.47 36.48,98.47 36.68,98.26 36.68,97.9 36.91,97.67 37.28,97.67 37.48,97.46 37.48,97.11 37.48,97.1 37.71,96.87 38.05,96.87 38.28,96.64 38.28,94.67 37.79,94.18 37.79,92.97 37.67,92.85 37.67,90.69 37.58,90.6 37.58,90.12 37.28,89.81 36.85,89.81 36.38,89.35 36.38,87.67 v1(35.58,86.87)
LPDDR4_DQ13: length 16.4
  TOP w0.267: U26.E9 v1(34.93,87.67) ; U18.G4 v1(36.28,98.07)
  L03_SIG01 w0.14: v1(36.28,98.07) 36.28,97.85 36.68,97.45 36.68,97.03 36.84,96.87 37.27,96.87 37.48,96.65 37.48,95.5 37.37,95.38 37.37,93.24 37.24,93.11 37.24,90.92 36.74,90.42 36.74,90.23 36.08,89.57 36.08,88.24 35.9,88.07 34.37,88.07 34.2,87.9 34.2,87.58 34.71,87.07 35.04,87.07 35.18,87.21 35.18,87.41 v1(34.93,87.67)
LPDDR4_DQ14: length 16.4
  TOP w0.267: U26.C9 v1(33.63,87.67) ; U18.E4 v1(33.88,97.27)
  L03_SIG01 w0.14: v1(33.63,87.67) 33.23,87.27 32.71,87.27 32.51,87.47 31.96,87.47 31.76,87.27 30.91,87.27 30.18,87.99 30.18,91.58 31.08,92.47 31.08,93.78 31.88,94.58 31.88,95.04 32.11,95.27 32.46,95.27 32.68,95.48 32.68,95.86 32.88,96.07 33.25,96.07 33.48,96.3 33.48,96.86 v1(33.88,97.27)
LPDDR4_DQ15: length 16.3
  TOP w0.267: U18.D3 v1(33.08,96.47) ; U26.B9 v1(32.98,86.87)
  L03_SIG01 w0.14: v1(33.08,96.47) 32.68,96.86 31.3,96.86 31.08,96.65 31.08,94.43 30.66,94.01 30.66,92.65 29.77,91.75 29.77,87.8 30.72,86.85 32.96,86.85 v1(32.98,86.87)
LPDDR4_DQ16: length 25.3
  TOP w0.267: U18.T6 v1(43.48,98.87) ; U26.AA2 v1(45.98,81.27)
  L05_SIG02 w0.14: v1(43.48,98.87) 43.88,98.47 46.05,98.47 46.28,98.23 46.28,97.9 46.51,97.67 46.85,97.67 47.08,97.43 47.08,97.1 47.31,96.86 47.65,96.86 47.88,96.63 47.88,96.3 48.11,96.07 48.45,96.07 48.71,95.8 48.71,94.7 48.3,94.29 48.3,92.65 49.5,91.45 49.5,83.98 46.78,81.27 v1(45.98,81.27)
LPDDR4_DQ17: length 25.3
  TOP w0.267: U26.Y2 v1(45.33,82.07) ; U18.T4 v1(43.48,97.27)
  L05_SIG02 w0.14: v1(43.48,97.27) 43.48,97.55 43.58,97.65 43.77,97.65 43.88,97.54 43.88,97.07 44.09,96.87 46.05,96.87 46.28,96.63 46.28,96.3 46.51,96.07 46.85,96.07 47.08,95.83 47.08,95.22 46.98,95.13 46.82,95.13 46.7,95.01 46.7,94.61 46.84,94.46 47.31,94.46 47.45,94.32 47.45,94.13 47.32,93.99 46.45,93.99 46.31,93.85 46.31,93.64 46.42,93.52 47.27,93.52 47.44,93.35 47.44,92.31 48.66,91.09 48.66,84.34 46.79,82.47 45.73,82.47 v1(45.33,82.07)
LPDDR4_DQ18: length 25.3
  TOP w0.267: U18.U5 v1(44.28,98.07) ; U26.V2 v1(44.03,81.27)
  L05_SIG02 w0.14: v1(44.03,81.27) 44.03,80.88 44.17,80.74 45.12,80.74 45.39,81.01 45.39,81.35 45.71,81.67 46.58,81.67 49.08,84.16 49.08,91.26 47.88,92.46 47.88,95.8 47.88,95.83 47.65,96.07 47.31,96.07 47.08,96.3 47.08,96.63 46.85,96.86 46.51,96.86 46.28,97.1 46.28,97.44 46.06,97.67 44.68,97.67 v1(44.28,98.07)
LPDDR4_DQ19: length 25.3
  TOP w0.267: U18.R5 v1(41.88,98.07) ; U26.U2 v1(42.73,81.27)
  L05_SIG02 w0.14: v1(41.88,98.07) 41.48,97.67 39.68,97.67 38.88,96.87 38.52,96.87 38.28,96.63 38.28,96.3 38.05,96.07 37.71,96.07 37.48,95.83 37.48,95.3 37.37,95.19 37.37,92.05 38.38,91.05 38.38,88.16 39.07,87.47 39.07,85.11 39.33,84.85 39.61,84.85 39.89,84.57 39.89,83.86 40.35,83.4 40.35,82.33 40.24,82.22 40.24,81.73 41.22,80.76 42.22,80.76 v1(42.73,81.27)
LPDDR4_DQ20: length 25.3
  TOP w0.267: U26.U4 v1(42.73,82.87) ; U18.P2 v1(41.88,95.67)
  L05_SIG02 w0.14: v1(41.88,95.67) U18.P2 39.84,96.07 38.76,94.98 38.76,93.96 38.61,93.81 38.61,92.4 39.69,91.32 40.65,91.32 40.87,91.1 40.87,89.95 41.01,89.81 41.24,89.81 41.37,89.93 41.37,90.09 41.51,90.23 41.87,90.23 42.1,90 42.1,89.08 42.32,88.87 43.42,88.87 43.56,88.73 43.56,88.48 43.38,88.3 43.38,87.96 43.59,87.75 43.59,87.5 43.47,87.38 43.19,87.38 42.98,87.17 42.8,87.17 42.65,87.02 42.65,86.53 42.81,86.37 43.16,86.37 43.47,86.06 43.47,85.49 43.24,85.27 42.72,85.27 42.59,85.4 42.24,85.4 42.1,85.26 42.1,84.96 42.23,84.83 42.23,84.42 42.4,84.25 43.06,84.25 43.3,84.01 43.3,83.44 v1(42.73,82.87)
LPDDR4_DQ21: length 25.3
  TOP w0.267: U26.V4 v1(43.38,82.87) ; U18.R3 v1(41.88,96.47)
  L05_SIG02 w0.14: v1(41.88,96.47) 41.48,96.87 39.53,96.87 39.14,96.47 39.14,96.26 38.94,96.07 38.51,96.07 38.28,95.83 38.28,94.56 38.12,94.41 37.93,94.41 37.79,94.27 37.79,92.39 38.25,91.93 38.39,91.93 39.94,90.38 39.94,89.64 39.73,89.43 39.73,89.1 40.05,88.78 40.54,88.78 40.74,88.58 40.74,87.91 40.55,87.73 40.09,87.73 39.95,87.58 39.95,87.3 40.16,87.09 40.16,86.82 39.95,86.61 39.95,86.31 40.13,86.12 40.13,85.84 39.95,85.65 39.95,85.19 40.11,85.02 40.46,85.02 40.6,85.16 40.6,85.33 40.72,85.45 41.21,85.45 41.36,85.3 41.36,83.69 41.92,83.13 41.92,82.93 42.39,82.47 42.98,82.47 v1(43.38,82.87)
LPDDR4_DQ22: length 25.3
  TOP w0.267: v1(45.98,83.67) 45.41,83.67 U26.Y4 ; U18.T2 v1(43.48,95.67)
  L05_SIG02 w0.14: v1(45.98,83.67) 46.8,83.67 47.82,84.69 47.82,89.67 47.68,89.81 46.99,89.81 46.87,89.93 46.87,90.14 46.99,90.26 47.69,90.26 47.82,90.39 47.82,90.69 47.66,90.85 47.45,90.85 47.31,90.71 46.49,90.71 46.35,90.85 46.35,91.61 46.21,91.75 45.51,91.75 45.07,92.19 44.19,92.19 43.93,92.45 43.51,92.45 43.24,92.19 42.92,92.19 42.71,92.39 42.71,92.74 43.1,93.13 43.1,93.99 43.28,94.17 44.02,94.17 44.27,94.41 45.16,94.41 45.41,94.67 45.41,95.07 45.22,95.25 44.9,95.25 44.68,95.04 44.41,95.04 44.19,95.25 43.89,95.25 v1(43.48,95.67)
LPDDR4_DQ23: length 25.3
  TOP w0.267: U26.AA4 v1(45.33,82.87) ; U18.U3 v1(43.48,96.47)
  L05_SIG02 w0.14: v1(45.33,82.87) 45.73,83.27 46.29,83.27 46.51,83.04 46.77,83.04 48.24,84.51 48.24,90.91 47.66,91.49 47.48,91.49 47.12,91.13 46.92,91.13 46.78,91.28 46.78,91.48 47.13,91.84 47.13,92.02 46.96,92.19 45.68,92.19 45.56,92.31 45.56,92.53 45.66,92.63 46.88,92.63 47.02,92.77 47.02,92.97 46.91,93.08 46.01,93.08 45.87,93.22 45.87,93.73 45.59,94.01 45.59,94.25 45.77,94.42 46.14,94.42 46.28,94.56 46.28,95.83 46.05,96.07 43.88,96.07 v1(43.48,96.47)
LPDDR4_DQ24: length 19.6
  TOP w0.267: U18.Y2 v1(46.68,95.67) ; U26.AA11 v1(45.98,88.46)
  L03_SIG01 w0.14: v1(45.98,88.46) 46.88,89.37 46.88,89.82 47.02,89.96 47.22,89.96 47.36,89.82 47.36,89.51 47.5,89.37 47.73,89.37 48.11,89.76 48.11,90.52 47.97,90.66 47.7,90.66 47.44,90.4 47.01,90.4 46.84,90.56 46.84,90.87 46.98,91.01 47.32,91.01 47.46,91.15 47.46,91.34 47.32,91.48 46.8,91.48 46.66,91.62 46.66,91.83 46.8,91.97 47.32,91.97 47.46,92.11 47.46,92.34 47.32,92.48 46.51,92.48 46.31,92.68 46.31,92.89 46.45,93.03 47.32,93.03 47.46,93.17 47.46,93.37 47.32,93.5 46.04,93.5 45.9,93.64 45.9,93.84 46.04,93.98 47.32,93.98 47.46,94.12 47.46,94.34 47.33,94.47 46.84,94.47 46.72,94.58 46.72,94.86 47.08,95.21 47.08,95.52 46.93,95.67 v1(46.68,95.67)
LPDDR4_DQ25: length 19.6
  TOP w0.267: U26.Y11 v1(44.68,89.26) ; U18.V2 v1(44.28,96.47)
  L03_SIG01 w0.14: v1(44.28,96.47) 44.28,96.73 44.14,96.87 41.7,96.87 41.48,96.65 41.48,96.28 41.27,96.07 40.91,96.07 40.68,95.83 40.68,95.36 40.51,95.18 40.14,95.18 40.03,95.07 40.03,94.73 40.14,94.61 40.46,94.61 40.57,94.5 40.57,94.17 40.33,93.92 40.33,93.67 40.53,93.47 40.53,93.11 40.39,92.97 40.08,92.97 39.84,92.74 39.84,92.23 39.57,91.95 39.57,91.75 39.73,91.59 39.93,91.59 40.33,92 40.62,92 40.89,92.27 41.13,92.27 41.27,92.12 41.27,91.93 41.04,91.7 41.04,91.5 41.23,91.31 41.45,91.31 41.6,91.47 41.98,91.47 42.14,91.31 43.1,91.31 43.75,90.66 43.75,89.52 44.01,89.26 v1(44.68,89.26)
LPDDR4_DQ26: length 19.6
  TOP w0.267: U26.V11 v1(43.38,89.26) ; U18.V4 v1(45.08,97.27)
  L03_SIG01 w0.14: v1(45.08,97.27) 45.08,97.53 44.94,97.67 41.7,97.67 41.48,97.45 41.48,97.1 41.25,96.87 40.9,96.87 40.68,96.65 40.68,96.3 40.45,96.07 39.89,96.07 39.64,95.82 39.64,94.45 39.31,94.12 39.31,93.04 39.42,92.93 39.42,92.42 39.06,92.06 39.06,91.66 39.74,90.99 39.94,90.99 40.34,91.39 40.55,91.39 40.87,91.07 40.87,90.89 41.3,90.46 41.92,90.46 42.35,90.88 42.81,90.88 42.95,90.75 42.95,90.54 42.84,90.43 42.84,90.1 42.75,90.01 42.75,89.79 42.87,89.67 43.24,89.67 43.38,89.52 v1(43.38,89.26)
LPDDR4_DQ27: length 19.6
  TOP w0.267: U18.W5 v1(45.88,98.07) ; U26.U11 v1(42.73,88.46)
  L03_SIG01 w0.14: v1(42.73,88.46) 42.11,89.09 42.11,89.33 41.38,90.06 41.13,90.06 40.69,90.5 39.64,90.5 38.61,91.52 38.61,93.33 38.87,93.59 38.87,94.27 39.19,94.6 39.19,95.97 40.09,96.87 40.45,96.87 40.68,97.1 40.68,97.43 40.91,97.67 41.25,97.67 41.48,97.89 41.48,98.23 41.71,98.47 U18.W5 v1(45.88,98.07)
LPDDR4_DQ28: length 19.6
  TOP w0.267: U26.U9 v1(43.38,86.87) ; U18.Y4 v1(46.68,97.27)
  L03_SIG01 w0.14: v1(46.68,97.27) 46.28,96.87 44.9,96.87 44.68,96.65 44.68,96.28 44.47,96.07 42.49,96.07 42.28,95.86 42.28,95.47 41,94.19 41,93.06 42.33,91.73 43.39,91.73 45.1,90.02 45.1,89.12 44.79,88.81 44.4,88.81 44.33,88.89 43.69,88.89 43.47,88.67 43.47,87.41 43.38,87.32 v1(43.38,86.87)
LPDDR4_DQ29: length 19.6
  TOP w0.267: U18.AA3 v1(47.48,96.47) ; U26.V9 v1(44.03,86.87)
  L03_SIG01 w0.14: v1(44.03,86.87) 44.43,87.27 46.8,87.27 47.45,87.91 47.45,88.2 47.61,88.37 47.91,88.37 49.89,90.35 49.89,91.53 49.68,91.74 49.2,91.74 48.31,92.62 48.31,94.27 48.88,94.84 49.83,94.84 49.97,94.98 49.97,95.18 49.86,95.3 49.86,95.49 49.97,95.61 49.97,95.83 49.83,95.97 49.59,95.97 49.27,96.29 49.27,96.6 49.13,96.74 48.64,96.74 48.51,96.87 47.88,96.87 v1(47.48,96.47)
LPDDR4_DQ30: length 19.6
  TOP w0.267: U18.AA5 v1(47.48,98.07) ; U26.Y9 v1(45.33,86.87)
  L03_SIG01 w0.14: v1(45.33,86.87) 45.95,86.24 47.02,86.24 51.8,91.03 51.8,95.33 49.45,97.68 48.53,97.68 48.51,97.66 47.88,97.66 v1(47.48,98.07)
LPDDR4_DQ31: length 19.6
  TOP w0.267: U26.AA9 v1(45.98,86.87) ; U18.AB4 v1(48.28,97.26)
  L03_SIG01 w0.14: v1(45.98,86.87) 47.01,86.87 50.54,90.4 50.54,90.59 50.32,90.82 50.32,91.01 50.46,91.15 50.65,91.15 50.87,90.92 51.07,90.92 51.39,91.24 51.39,91.51 51.25,91.64 50.83,91.64 50.7,91.78 50.7,91.98 50.84,92.13 51.25,92.13 51.39,92.26 51.39,95.15 51.2,95.34 51.01,95.34 50.87,95.2 50.87,94.84 50.73,94.71 50.55,94.71 50.41,94.85 50.41,96.1 49.24,97.26 v1(48.28,97.26)
LPDDR4_DQS0_N: length 25.7
  TOP w0.203: v1(34.93,82.07) U26.E3 ; U18.C1 v1(32.28,94.87)
  L05_SIG02 w0.127: v1(34.93,82.07) 34.55,82.44 34.41,82.44 34.13,82.72 34.13,83.73 33.79,84.06 31.06,84.06 30.65,84.47 30.65,84.74 30.17,85.23 29.89,85.23 29.6,85.52 29.6,85.97 29.88,86.25 30.56,86.25 30.69,86.37 30.69,86.62 30.53,86.78 29.78,86.78 29.49,87.07 29.49,87.48 29.78,87.77 30.53,87.77 30.69,87.92 30.69,88.14 30.53,88.3 29.78,88.3 29.49,88.59 29.49,89 29.78,89.29 30.53,89.29 30.69,89.45 30.69,89.73 30.54,89.88 29.75,89.88 29.47,90.17 29.47,90.8 29.76,91.1 30.08,91.1 31.28,92.29 31.28,93.23 31.57,93.52 32.47,93.52 32.63,93.68 32.63,94.09 32.46,94.26 32.46,94.61 32.46,94.69 v1(32.28,94.87)
LPDDR4_DQS0_P: length 25.7
  TOP w0.203: v1(34.93,82.86) U26.D3 ; U18.D1 v1(33.08,94.86)
  L05_SIG02 w0.127: v1(34.93,82.86) 34.74,82.67 34.5,82.67 34.36,82.82 34.36,83.82 33.89,84.29 31.16,84.29 30.88,84.57 30.88,84.84 30.26,85.46 29.98,85.46 29.83,85.61 29.83,85.87 29.98,86.02 30.66,86.02 30.92,86.28 30.92,86.71 30.63,87 29.88,87 29.72,87.16 29.72,87.38 29.88,87.54 30.63,87.54 30.92,87.83 30.92,88.24 30.63,88.53 29.88,88.53 29.72,88.68 29.72,88.91 29.88,89.06 30.63,89.06 30.92,89.35 30.92,89.83 30.63,90.11 29.84,90.11 29.69,90.26 29.69,90.71 29.86,90.87 30.18,90.87 31.51,92.2 31.51,93.13 31.67,93.29 32.57,93.29 32.85,93.58 32.85,94.19 32.69,94.35 32.69,94.7 32.69,94.9 32.77,94.99 32.95,94.99 v1(33.08,94.86)
LPDDR4_DQS1_N: length 16.4
  TOP w0.203: U18.F1 v1(35.48,95.67) ; U26.E10 v1(35.58,88.47)
  L03_SIG01 w0.127: v1(35.48,95.67) 35.48,95.45 35.87,95.06 35.87,94.59 35.79,94.51 35.79,93.9 35.53,93.64 34.54,93.64 34.27,93.38 33.63,93.38 33.03,92.77 33.03,90.94 33.16,90.81 33.34,90.81 33.47,90.93 33.47,92.57 33.74,92.84 34.11,92.84 34.37,92.58 34.37,90.59 34.26,90.48 34.26,89.37 34.77,88.86 35.17,88.86 35.57,88.47 v1(35.58,88.47)
LPDDR4_DQS1_P: length 16.4
  TOP w0.203: U26.D10 v1(34.93,88.47) ; v1(35.48,94.87) U18.G1
  L03_SIG01 w0.127: v1(35.48,94.87) 35.27,95.08 35.1,95.08 34.86,94.83 34.86,94.51 34.98,94.38 35.48,94.38 35.57,94.29 35.57,93.99 35.44,93.87 34.44,93.87 34.18,93.6 33.54,93.6 32.8,92.86 32.8,90.85 33.07,90.58 33.44,90.58 33.7,90.84 33.7,92.47 33.83,92.61 34.01,92.61 34.14,92.49 34.14,90.68 34.03,90.58 34.03,89.28 34.68,88.63 34.76,88.63 v1(34.93,88.47)
LPDDR4_DQS2_N: length 25.3
  TOP w0.203: v1(41.48,93.9) 41.7,94.11 41.7,95.05 U18.P1 ; U26.V3 v1(44.03,82.07)
  L05_SIG02 w0.127: v1(44.03,82.07) 44.24,82.28 44.24,82.41 44,82.65 44,83.89 44.4,84.29 44.71,84.29 44.95,84.54 44.95,84.95 45.39,85.39 46.43,85.39 46.71,85.67 46.71,87.3 46.38,87.63 46.38,88.63 44.76,90.25 44.76,90.38 44.38,90.75 42.53,90.75 41.37,91.91 40,91.91 39.52,92.4 39.52,92.65 39.24,92.93 39.24,94.28 39.62,94.66 40.26,94.66 40.72,94.2 40.72,93.95 41.33,93.35 41.62,93.35 41.75,93.48 41.75,93.62 v1(41.48,93.9)
LPDDR4_DQS2_P: length 25.3
  TOP w0.203: U26.W3 v1(44.68,82.07) ; U18.R1 42.04,95.02 42.04,94.1 v1(42.24,93.9)
  L05_SIG02 w0.127: v1(44.68,82.07) 44.47,82.28 44.47,82.51 44.23,82.75 44.23,83.8 44.5,84.06 44.8,84.06 45.18,84.44 45.18,84.85 45.48,85.16 46.53,85.16 46.94,85.57 46.94,87.39 46.61,87.72 46.61,88.73 44.98,90.35 44.98,90.47 44.47,90.98 42.62,90.98 41.46,92.14 40.1,92.14 39.75,92.49 39.75,92.75 39.47,93.02 39.47,94.18 39.72,94.43 40.17,94.43 40.5,94.1 40.5,93.86 41.23,93.12 41.72,93.12 41.98,93.38 41.98,93.63 v1(42.24,93.9)
LPDDR4_DQS3_N: length 19.6
  TOP w0.203: v1(44.03,87.67) U26.V10 ; U18.Y1 v1(45.88,95.67)
  L03_SIG01 w0.127: v1(45.88,95.67) 45.48,95.27 45.48,94.78 45.35,94.65 44.78,94.65 44.19,95.25 42.68,95.25 42.33,94.9 42.33,94.41 42.83,93.91 42.83,93.57 42.7,93.45 42.24,93.45 41.98,93.19 41.98,92.72 42.38,92.33 43.54,92.33 44.41,91.45 44.82,91.45 45.6,92.23 45.82,92.23 45.99,92.06 45.99,91.8 45.57,91.38 45.57,90.97 46.21,90.33 46.21,89.68 44.92,88.39 44.58,88.39 44.31,88.12 44.31,87.95 v1(44.03,87.67)
LPDDR4_DQS3_P: length 19.6
  TOP w0.203: U18.W1 v1(45.88,94.86) ; v1(44.68,87.67) U26.W10
  L03_SIG01 w0.127: v1(45.88,94.86) 46.18,94.86 46.3,94.74 46.3,94.56 46.17,94.43 44.69,94.43 44.1,95.02 42.77,95.02 42.56,94.8 42.56,94.51 43.06,94.01 43.06,93.48 42.79,93.22 42.34,93.22 42.21,93.09 42.21,92.82 42.47,92.56 43.63,92.56 44.51,91.68 44.73,91.68 45.5,92.46 45.91,92.46 46.22,92.15 46.22,91.71 45.8,91.29 45.8,91.06 46.43,90.42 46.43,89.59 45.01,88.16 44.68,88.16 44.54,88.02 44.54,87.81 v1(44.68,87.67)
LPDDR4_ODT_CA_A: length 3.3
  TOP w0.267: U26.G2 v1(36.23,81.27)
  L10_SIG03 w0.14: v1(36.23,81.27) 36.72,80.78 36.72,80.46 36.62,80.36 36.62,80.08 36.72,79.97 v1(36.72,79.46)
  BOTTOM w0.267: R370.1 v1(36.72,79.46)
LPDDR4_ODT_CA_B: length 3.1
  TOP w0.267: U26.T2 v1(42.08,81.27)
  L10_SIG03 w0.14: v1(42.02,79.38) 42.02,79.38 42.02,80.74 42.08,80.8 v1(42.08,81.27)
  BOTTOM w0.267: R369.1 v1(42.02,79.38)
LPDDR4_RESET_N: length 16
  TOP w0.267: U18.P6 v1(41.08,98.87) ; U26.T11 v1(42.73,89.26)
  BOTTOM w0.114: 39.76,98.27 39.96,98.47 40.68,98.47 v1(41.08,98.87)
  BOTTOM w0.267: 39.76,98.27 39.76,95.05 40.7,94.11 40.7,93.69 41.79,92.6 R350.2 R352.1 42.4,91.08 42.64,90.84 43.52,90.84 43.77,90.58 43.77,89.77 43.96,89.58 43.96,89.15 43.6,88.79 43.12,88.79 42.73,89.18 v1(42.73,89.26)
LPDDR4_ZQ0: length 1.4
  TOP w0.267: R122.2 31.89,84.07 32.01,84.18 32.54,84.18 U26.A5
LPDDR4_ZQ1: length 1.3
  TOP w0.267: U26.A8 R119.2
M2_LED1#: length 2.1
  TOP w0.14: J2.6 v1(8.97,135.79)
  BOTTOM w0.14: TP95.1 v1(8.97,135.79)
M2_LED2#: length 2.1
  TOP w0.14: J2.16 v1(8.97,138.29)
  BOTTOM w0.14: TP92.1 v1(8.97,138.29)
MCASP1_ACLKX_AUD: length 124.5
  TOP w0.14: TP56.1 v1(72.16,52.41)
  L05_SIG02 w0.102: v1(45.46,140.63) 45.23,140.86 45.23,142.03 47.34,144.14 47.34,144.65 48.55,145.86 58.34,145.86 59.62,144.58 61.09,144.58 68.88,136.79 68.88,132.82 70.46,131.25 70.46,124.39 68.34,122.28 68.34,110.95 69.45,109.85 69.45,103.37 67.82,101.74 67.82,80.16 69.66,78.32 69.66,54.61 71.87,52.41 v1(72.16,52.41)
  BOTTOM w0.14: v1(45.46,140.63) 44.34,140.63 43.74,140.04 U52.3 ; U88.38 v1(72.16,52.41)
MCASP1_ACLKX_BT: length 42.4
  TOP w0.14: v1(12.32,136.5) 12.05,136.5 11.83,136.29 J2.8
  L10_SIG03 w0.102: v1(48.36,140.49) 47.63,141.22 44.65,141.22 41.46,138.02 35.96,138.02 33.61,135.68 25.86,135.68 24.69,136.84 12.66,136.84 v1(12.32,136.5)
  BOTTOM w0.14: U51.5 48.24,141.1 48.45,140.89 48.45,140.58 v1(48.36,140.49)
MCASP1_ACLKX_BUF: length 36.5
  TOP w0.132: U18.L19 v1(38.68,110.06)
  BOTTOM w0.14: U51.7 46.09,141.1 46,141.19 44.35,141.19 43.09,139.93 U52.4 43.09,137.92 42.65,137.48 42.65,137.13 40.91,135.39 40.91,126.26 40.71,126.07 40.71,119.06 40.41,118.76 40.41,115.23 39.25,114.06 39.25,110.63 v1(38.68,110.06)
MCASP1_ACLKX_HDMI: length 39.8
  TOP w0.14: U13.45 20.69,122.74 v1(21.42,123.46)
  L05_SIG02 w0.102: v1(44.39,140.04) 43.53,139.17 34.33,139.17 31.68,136.53 24.65,136.53 20.5,132.38 20.5,127.52 21.87,126.15 21.87,123.91 v1(21.42,123.46)
  BOTTOM w0.14: U52.2 v1(44.39,140.04)
MCASP1_AFSX_AUD: length 134.4
  TOP w0.14: v1(72.49,53.54) 72.65,53.38 TP52.1
  L05_SIG02 w0.102: v1(41.79,140.05) 39.81,142.03 39.81,143.94 40.44,144.57 44.02,144.57 46.87,147.42 58.72,147.42 59.38,146.76 61.9,146.76 66.47,142.19 66.97,142.19 67.56,141.61 67.56,141 68.14,140.42 68.75,140.42 69.87,139.3 69.87,138.66 70.58,137.95 71.8,137.95 72.15,137.6 72.15,124.34 73.12,123.37 73.12,111.84 70.25,108.97 70.25,102.93 70.59,102.59 70.59,87.85 69.94,87.2 69.94,79.59 70.59,78.95 70.59,55.44 v1(72.49,53.54)
  BOTTOM w0.14: v1(72.49,53.54) 72.49,53.15 72.48,53.14 72.48,52.89 72.66,52.71 U88.39 ; U52.6 v1(41.79,140.05)
MCASP1_AFSX_BT: length 42.7
  TOP w0.14: J2.10 v1(11.42,136.79)
  L10_SIG03 w0.102: v1(11.42,136.79) 11.7,137.07 24.97,137.07 26.11,135.93 33.47,135.93 35.91,138.37 41.3,138.37 44.39,141.47 48.86,141.47 v1(48.96,141.37)
  BOTTOM w0.14: U51.4 48.83,141.5 v1(48.96,141.37)
MCASP1_AFSX_BUF: length 49.3
  TOP w0.132: U18.R18 v1(42.68,109.26)
  TOP w0.14: v1(40.91,140.08) 41.92,141.09 44.12,141.09 45.45,139.76 45.45,137.89 46.04,137.3 46.04,136.45 46.21,136.28 v1(46.21,135.46)
  BOTTOM w0.14: v1(46.21,135.46) 48.64,133.02 48.64,127.52 47.39,126.26 45.46,126.26 44.6,125.41 44.6,124.17 43.08,122.64 43.08,109.66 v1(42.68,109.26) ; U51.8 42.33,141.5 v1(40.91,140.08) 41.14,139.85 U52.7
MCASP1_AFSX_HDMI: length 43.6
  TOP w0.14: U13.44 21.19,122.63 21.51,122.94 22.01,122.94 v1(22.31,123.24)
  L05_SIG02 w0.102: v1(22.31,123.24) 22.31,126.12 20.81,127.62 20.81,132.01 24.98,136.19 32.5,136.19 35.06,138.74 44.02,138.74 44.82,139.54 44.82,140.28 44.5,140.59 v1(42.44,140.59)
  BOTTOM w0.14: U52.5 v1(42.44,140.59)
MCASP1_AXR0_AUD: length 126.1
  TOP w0.14: TP57.1 v1(73.16,52.41)
  L05_SIG02 w0.102: v1(73.16,52.41) 72.72,52.85 71.94,52.85 70,54.79 70,78.41 68.11,80.29 68.11,101.62 69.72,103.23 69.72,109.91 70.48,110.67 70.48,123.78 70.75,124.05 70.75,131.66 69.8,132.61 69.8,136.38 68.23,137.95 68.23,138.99 66.94,140.28 66.17,140.28 60.42,146.03 59.16,146.03 58.23,146.96 47.53,146.96 44.26,143.69 41.74,143.69 v1(41.14,143.09)
  BOTTOM w0.14: U88.40 v1(73.16,52.41) ; U52.10 v1(41.14,143.09)
MCASP1_AXR0_BT: length 46.1
  TOP w0.14: J2.12 12.66,137.29 v1(13.68,138.31)
  L10_SIG03 w0.102: v1(13.68,138.31) 14.68,138.31 15.06,137.94 16.17,137.94 16.64,138.41 17.04,138.41 17.92,137.53 25.55,137.53 26.62,136.46 32.87,136.46 35.64,139.24 38.72,139.24 40.21,140.73 41.86,140.73 43.72,142.59 46.72,142.59 47.04,142.91 49.35,142.91 v1(49.39,142.87)
  BOTTOM w0.14: v1(49.39,142.87) 49.43,142.87 49.63,142.67 R256.2 49.04,141.9 49.03,141.9 U51.3
MCASP1_AXR0_BUF: length 47.7
  TOP w0.132: U18.K19 v1(37.88,110.06)
  BOTTOM w0.14: v1(37.88,110.06) 37.48,110.46 36.86,110.46 36.68,110.64 36.68,112.75 36.72,112.78 36.72,114.68 37.88,115.85 37.88,122.46 35.92,124.42 35.92,131.59 36.6,132.27 36.6,135.05 38.24,136.69 38.24,140.31 40,142.07 40,144.16 40.22,144.38 U52.9 40.49,142.47 41.28,141.68 41.87,141.68 42.08,141.9 U51.9
MCASP1_AXR0_HDMI: length 44
  TOP w0.14: U13.41 22.69,122.66 v1(23.3,123.27)
  L05_SIG02 w0.102: v1(23.3,123.27) 23.05,123.53 23.05,133.32 25.46,135.73 32.52,135.73 35.02,138.24 43.92,138.24 45.12,139.43 45.12,140.4 43.33,142.18 v1(41.5,142.18)
  BOTTOM w0.14: v1(41.5,142.18) 41.79,142.48 U52.11
MCASP1_AXR2: length 13.1
  TOP w0.132: U18.L18 v1(38.68,109.26)
  TOP w0.14: v1(41.71,117.16) 41.11,117.76 R52.2 R51.2
  BOTTOM w0.14: v1(41.71,117.16) 41.48,116.93 41.48,109.9 41.25,109.67 39.08,109.67 v1(38.68,109.26)
MCASP1_AXR2_AUD: length 131.3
  TOP w0.14: TP51.1 73.17,54.25 v1(73.18,54.24)
  L05_SIG02 w0.102: v1(43.27,143.07) 42.88,142.68 40.95,142.68 40.71,142.92 40.71,143.77 40.98,144.03 44.05,144.03 47.2,147.19 58.46,147.19 59.31,146.34 60.73,146.34 66.56,140.51 67.4,140.51 68.65,139.26 68.65,138.12 71.06,135.71 71.06,132.24 71.82,131.47 71.82,124.64 70.83,123.65 70.83,110.52 69.97,109.66 69.97,103.09 68.35,101.47 68.35,80.59 70.28,78.65 70.28,55 72.17,53.11 72.8,53.11 73.18,53.49 v1(73.18,54.24)
  BOTTOM w0.14: U52.13 43.09,143.24 v1(43.27,143.07) ; R404.1 v1(73.18,54.24)
MCASP1_AXR2_BT: length 42.6
  TOP w0.14: J2.14 v1(11.42,137.79)
  L10_SIG03 w0.102: v1(48.79,142.38) 48.67,142.38 48.01,141.71 44.19,141.71 41.22,138.75 35.8,138.75 33.26,136.21 26.34,136.21 25.25,137.3 11.91,137.3 v1(11.42,137.79)
  BOTTOM w0.14: U51.2 48.59,142.3 48.67,142.38 v1(48.79,142.38)
MCASP1_AXR2_BUF: length 33.8
  TOP w0.14: v1(39.6,140.78) 39.6,141.22 41.01,142.63 41.93,142.63 v1(42.44,143.15) ; R51.1 v1(39.81,118.99)
  BOTTOM w0.14: v1(39.6,140.78) 38.84,140.02 38.84,135.6 38.46,135.22 38.46,126.79 40.26,124.98 40.26,119.44 v1(39.81,118.99) ; U52.12 v1(42.44,143.15) 43.3,142.3 U51.10
MCASP1_BUF_BT_EN: length 129.4
  TOP w0.14: R19.1 48.85,143.23 v1(49.24,143.62)
  L05_SIG02 w0.102: v1(57.8,43.11) 58.18,42.73 60.93,42.73 61.52,43.32 63.31,43.32 66.83,46.84 66.83,50.08 68.71,51.96 68.71,53.94 69.29,54.53 69.29,78.17 67.59,79.88 67.59,101.89 69.09,103.39 69.09,109.8 68.09,110.8 68.09,122.43 70.22,124.56 70.22,130.99 68.55,132.66 68.55,136.18 60.96,143.78 59.08,143.78 58.26,144.59 50.21,144.59 v1(49.24,143.62)
  BOTTOM w0.14: U92.20 v1(57.8,43.11)
MCASP1_BUF_BT_EN_1V8: length 2.7
  TOP w0.14: R19.2 48.02,143.71 47.66,144.07 R18.2 47.32,143.47 v1(47.39,143.39)
  BOTTOM w0.14: U51.12 v1(47.39,143.39)
MCASP1_FET_EN: length 134.4
  L05_SIG02 w0.102: v1(50.7,142.99) 54.98,142.99 56.96,141.01 61.97,141.01 67.69,135.28 67.69,128.4 68.62,127.47 68.62,123.51 67.86,122.75 67.86,110.71 68.77,109.8 68.77,103.42 67.16,101.81 67.16,98.6 66.45,97.88 66.45,91.24 67.36,90.34 67.36,79.24 68.99,77.61 68.99,54.55 68.46,54.01 68.46,52.06 66.55,50.15 66.55,46.88 63.25,43.59 61.41,43.59 60.93,43.11 v1(58.72,43.11)
  BOTTOM w0.14: v1(50.7,142.99) 49.83,143.86 49.83,145.21 48.73,146.32 46.33,146.32 45.97,145.96 R252.1 R253.2 44.27,145.55 44.39,145.42 U52.15 ; U92.19 58.22,43.61 v1(58.72,43.11)
MCASP1_FET_SEL: length 145.8
  TOP w0.132: R168.1 63.79,47.65 63.8,47.65 J12.1
  L03_SIG01 w0.102: J12.1 63.92,46.67 61.01,46.67 60.07,45.73 60.07,42.66 59.52,42.11 v1(58.72,42.11)
  L05_SIG02 w0.102: v1(46.22,138.46) 46.9,137.78 50.93,137.78 53.16,140.01 55.42,140.01 55.88,140.48 61.96,140.48 67.41,135.03 67.41,127.64 67.61,127.44 67.61,110.64 68.42,109.82 68.42,106.23 67.72,105.53 67.72,104.71 67.95,104.48 67.95,102.92 66.94,101.91 66.94,98.82 66.22,98.11 66.22,91.15 67.13,90.24 67.13,78.89 68.68,77.33 68.68,54.57 68.2,54.08 68.2,52.13 66.32,50.25 66.32,46.98 63.86,44.51 62.41,44.51 62.05,44.16 59.44,44.16 58.89,43.61 57.55,43.61 57.13,43.19 57.13,42.03 57.43,41.72 58.33,41.72 v1(58.72,42.11)
  BOTTOM w0.14: v1(46.22,138.46) 45.89,138.78 U52.1 ; U92.21 58.22,42.61 v1(58.72,42.11)
MCU_GPIO0_15: length 37.3
  TOP w0.14: R89.2 21.84,99.84 21.99,99.69 v1(21.99,99.31)
  L05_SIG02 w0.102: v1(21.99,99.31) 22.51,98.79 22.51,96.58 21.9,95.97 21.9,94.57 22.13,94.35 22.13,89.52 21.84,89.24 21.84,84.67 23.29,83.21 23.29,70.53 23.48,70.33 23.48,65.74 J8.10
MCU_GPIO0_15_R: length 17
  TOP w0.132: U18.D7 v1(33.08,99.67)
  TOP w0.14: v1(22.49,100.08) 22.18,100.4 R89.1 R88.2
  BOTTOM w0.14: v1(33.08,99.67) 32.68,99.27 32.68,97.87 32.48,97.67 28.65,97.67 26.79,99.52 26.79,100.06 26.07,100.78 22.74,100.78 22.49,100.53 v1(22.49,100.08)
MCU_GPIO0_16: length 1.6
  BOTTOM w0.14: R573.2 J8.11
MCU_I2C0_SCL: length 86.6
  TOP w0.132: v1(13.61,81.54) U27.32 ; U18.E12 v1(33.88,104.46)
  L05_SIG02 w0.102: v1(26.58,76.44) 26.58,73.58 29.09,71.08 29.09,66.76 29.59,66.26 30.73,66.26 30.87,66.13 32.7,66.13 33.53,65.3 33.53,64.15 34.04,63.64 41.13,63.64 J8.24
  L10_SIG03 w0.102: v1(22.68,74.69) 22.68,76.09 23.69,77.1 23.69,87.19 24.44,87.93 24.44,94.64 24.19,94.89 24.19,95.92 24.72,96.45 24.72,97.93 25.04,98.24 25.04,99.37 25.89,100.22 26.82,100.22 27.83,101.23 29.06,101.23 30.3,102.47 34.05,102.47 34.28,102.7 34.28,103.19 33.88,103.59 v1(33.88,104.46)
  BOTTOM w0.14: v1(13.61,81.54) 13.06,80.99 13.06,79.34 13.64,78.76 16.71,78.76 17.04,78.43 17.04,78.05 17.27,77.82 17.8,77.82 18.06,77.56 18.06,77.2 18.34,76.92 18.9,76.92 19.56,76.26 21.11,76.26 v1(22.68,74.69) 24.46,74.69 26.22,76.44 v1(26.58,76.44) ; R388.2 J8.24
MCU_I2C0_SDA: length 99.2
  TOP w0.132: U18.D9 v1(33.08,101.26)
  TOP w0.14: U27.33 12.42,81.04 v1(12.09,81.37) ; R137.2 19.5,66.84 v1(19.4,66.94)
  L05_SIG02 w0.102: v1(26.04,74.49) 26.04,73.81 28.86,70.99 28.86,66.67 29.5,66.03 30.63,66.03 30.76,65.9 32.54,65.9 33.26,65.18 33.26,64.06 33.89,63.44 34.12,63.44 38.49,63.44 J8.21
  L10_SIG03 w0.102: v1(12.09,81.37) 12.07,81.34 11.3,81.34 10.9,80.94 10.9,76.21 12.46,74.65 12.46,68.05 14.04,66.47 18.93,66.47 v1(19.4,66.94) ; v1(33.08,101.26) 32.9,101.26 32.5,100.86 30.77,100.86 29.44,99.53 29.44,98.79 27.2,96.55 26.54,96.55 26.16,96.17 26.16,83.97 24.74,82.55 24.74,77.72 25.61,76.85 25.61,74.92 v1(26.04,74.49)
  BOTTOM w0.14: J8.21 39.71,62.21 R391.2 ; v1(12.09,81.37) 12.12,81.37 12.61,80.88 12.61,79.25 14.04,77.82 16.7,77.82 17.03,77.49 17.03,77.23 17.35,76.91 17.93,76.91 18.29,76.54 18.83,76.54 19.55,75.82 20.94,75.82 22.48,74.28 25.22,74.28 25.42,74.49 v1(26.04,74.49)
