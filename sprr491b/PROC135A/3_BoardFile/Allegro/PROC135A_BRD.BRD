# Allegro board PROC135A_BRD.BRD (continued)
## Copper pours and planes (outline as drawn) (continued)
DGND on L03_SIG01 (solid shape): 22.94,64.24 22.97,64.22 22.98,64.19 22.98,60.97 22.98,60.95 22.99,60.94 23.66,60.27 23.67,60.25 23.67,60.23 23.67,54.29 23.68,54.27 23.69,54.25 24.45,53.49 24.46,53.48 24.46,53.46 24.46,53.24 24.45,53.21 24.43,53.19 24.42,53.19 24.39,53.19 23.2,54.38 23.19,54.39 23.19,54.41 23.19,57.02 23.18,57.04 23.17,57.06 21.54,58.69 21.52,58.7 21.5,58.7 20.79,58.7 20.78,58.71 20.76,58.72 20.1,59.38 20.09,59.4 20.08,59.42 20.08,59.79 20.09,59.82 20.11,59.84 20.2,59.89 20.23,59.89 20.24,59.88 20.55,59.86 20.74,60.11 20.75,60.14 21.14,60.53 21.15,60.54 21.15,60.56 21.15,63.88 21.16,63.91 21.18,63.93 21.27,63.97 21.3,63.97 21.31,63.96 22.12,63.77 22.79,64.24 22.8,64.26 22.83,64.27
DGND on L03_SIG01 (solid shape): 43.05,96.59 43.07,96.59 43.09,96.58 43.14,96.51 43.14,96.42 43.09,96.35 43.07,96.34 43.05,96.34 42.39,96.34 42.37,96.33 42.36,96.32 42.02,95.98 41.99,95.98 41.98,95.98 41.59,95.82 41.67,95.41 41.69,95.38 41.7,95.3 41.69,95.27 41.68,95.26 40.99,94.57 40.97,94.55 40.94,94.55 40.85,94.57 40.83,94.59 40.8,94.65 40.76,94.69 40.62,94.84 40.6,94.87 40.62,94.91 40.95,95.24 40.95,95.26 41.03,95.33 41.06,95.34 41.34,95.46 41.39,95.77 41.39,95.78 41.4,95.81 41.74,96.15 41.76,96.16 41.78,96.15 42.08,96.2 42.21,96.48 42.22,96.51 42.27,96.58 42.29,96.59 42.31,96.59
DGND on L03_SIG01 (solid shape): 28.58,99.74 28.6,99.73 28.62,99.72 28.67,99.64 28.68,99.62 28.67,99.61 28.68,99.4 28.8,99.24 28.81,99.24 28.82,99.22 28.83,99.13 28.83,99.11 28.81,99.09 27.32,97.59 27.31,97.58 27.31,97.56 27.31,95.19 27.3,95.17 27.29,95.16 26.66,94.52 26.63,94.51 26.6,94.51 26.59,94.52 26.57,94.54 26.57,96.54 26.58,96.56 26.59,96.57 26.65,96.63 26.68,96.64 27.05,96.97 26.68,97.29 26.65,97.3 26.59,97.36 26.58,97.37 26.57,97.4 26.57,98.13 26.58,98.15 26.59,98.17 27.7,99.28 27.71,99.29 27.73,99.29 27.82,99.29 27.85,99.27 28.27,99.2 28.41,99.6 28.4,99.61 28.41,99.64 28.46,99.72 28.48,99.73 28.5,99.74
DGND on L03_SIG01 (solid shape): outline of 84 points within 9.02,59.14 11.06,67.05
DGND on L03_SIG01 (solid shape): 33.85,89 33.88,88.98 34.43,88.43 34.45,88.4 34.45,88.37 34.44,88.36 34.41,88.34 34.28,88.34 34.26,88.33 34.24,88.32 33.94,88.03 33.93,88.01 33.92,87.96 33.9,87.94 33.87,87.93 33.85,87.92 33.82,87.93 33.59,87.99 33.38,87.88 33.37,87.87 33.35,87.87 33.26,87.87 33.24,87.87 33.23,87.88 33.13,87.96 33.01,87.99 32.98,88.01 32.97,88.04 32.98,88.08 33.04,88.13 33.06,88.14 33.15,88.18 33.23,88.25 33.25,88.26 33.27,88.26 33.34,88.26 33.36,88.26 33.38,88.25 33.91,88.29 33.71,88.79 33.69,88.8 33.63,88.85 33.62,88.89 33.63,88.92 33.74,88.95 33.81,88.99
DGND on L03_SIG01 (solid shape): 31.04,110.72 31.06,110.73 31.08,110.73 31.17,110.72 31.19,110.71 31.2,110.7 31.33,110.57 31.51,110.54 31.55,110.53 31.61,110.47 31.62,110.46 31.63,110.43 31.61,110.4 31.56,110.39 31.15,110.06 31.58,109.75 31.59,109.75 31.62,109.75 31.96,109.4 31.97,109.38 31.95,109.3 31.95,109.2 31.89,109.14 31.87,109.12 31.85,109.12 31.81,109.13 31.8,109.18 31.51,109.59 31.15,109.23 31.15,109.2 31.09,109.14 31.07,109.12 31.05,109.12 30.52,109.12 30.48,109.13 30.47,109.17 30.47,110.13 30.47,110.15 30.48,110.16
DGND on L03_SIG01 (solid shape): outline of 91 points within 27.13,19.89 28.58,23.45
DGND on L03_SIG01 (solid shape): 31.85,96.59 31.87,96.59 31.89,96.58 31.94,96.51 31.95,96.48 32.25,96.14 32.61,96.43 32.62,96.46 32.66,96.48 32.7,96.46 32.75,96.41 32.77,96.36 32.76,96.33 32.42,95.98 32.39,95.98 32.38,95.98 32.04,95.89 31.97,95.55 31.97,95.54 31.97,95.51 31.64,95.18 31.61,95.17 31.59,95.18 31.5,95.2 31.37,95.2 31.35,95.24 31.35,95.29 31.37,95.33 31.41,95.34 31.81,95.64 31.46,96 31.43,96 31.37,96.06 31.36,96.08 31.35,96.1 31.35,96.51 31.36,96.53 31.37,96.55 31.39,96.58 31.41,96.59 31.43,96.59
DGND on L03_SIG01 (solid shape): 71.82,32.69 71.85,32.69 71.87,32.67 71.92,32.58 71.92,32.56 71.89,32.49 71.87,32.41 71.36,31.9 71.34,31.88 71.34,31.86 71.34,30.83 71.34,30.81 71.36,30.8 71.88,30.27 71.9,30.26 71.92,30.26 72.15,30.26 72.17,30.25 72.19,30.24 72.38,30.05 72.39,30.03 72.4,30.01 72.4,29.23 72.39,29.21 72.37,29.19 72.35,29.18 72.32,29.19 72.12,29.39 72.08,29.4 72.05,29.42 72.04,29.45 72.04,29.64 72.03,29.66 72.02,29.67 71.17,30.53 71.15,30.54 71.13,30.55 69.94,30.55 69.92,30.55 69.89,30.57 69.89,30.6 69.88,30.69 69.61,30.95 69.6,30.99 69.6,31.8 69.61,31.83 69.69,31.91 69.68,31.98 69.65,31.99 67.72,31.99 67.69,32 67.67,32.02 67.67,32.04 67.67,32.07 68.09,32.49 68.11,32.5 68.13,32.5 69.12,32.5 69.14,32.51 69.16,32.52 69.23,32.68 69.27,32.69
DGND on L03_SIG01 (solid shape): 61.28,38.93 61.3,38.93 61.32,38.92 62.21,38.03 62.22,38.01 62.22,37.99 62.19,37.89 62.17,37.87 62.16,37.87 61.93,37.45 62.35,37.23 62.36,37.23 62.38,37.23 62.46,37.17 62.47,37.16 62.48,37.13 62.48,36.39 62.47,36.37 62.46,36.35 61.25,35.14 61.23,35.13 61.2,35.13 61.18,35.14 61.17,35.16 61.17,35.72 61.17,35.74 61.18,35.75 61.21,35.79 61.23,35.8 61.23,35.82 61.23,37.08 61.23,37.1 61.21,37.11 61.18,37.15 61.17,37.16 61.17,37.18 61.17,37.22 61.17,37.25 61.2,37.27 61.22,37.28 61.25,37.28 61.27,37.27 61.79,37.52 61.31,37.84 61.3,37.84 61.27,37.84 61.19,37.89 61.17,37.91 61.17,37.93 61.17,38.33 61.16,38.35 61.15,38.37 60.94,38.58 60.93,38.6 60.93,38.62 60.95,38.72 60.97,38.74 60.98,38.74 61.09,38.8 61.16,38.89 61.17,38.9 61.19,38.92
DGND on L03_SIG01 (solid shape): outline of 103 points within 43.17,21.77 48.43,23.25
DGND on L03_SIG01 (solid shape): 38.08,92.28 38.15,92.27 38.23,92.27 38.26,92.26 38.32,92.2 38.33,92.19 38.34,92.16 38.34,91.43 38.34,91.41 38.35,91.39 39.51,90.24 39.53,90.23 39.54,90.22 40.02,90.22 40.04,90.22 40.06,90.21 40.12,90.15 40.13,90.04 40.12,90.02 40.06,89.96 40.05,89.94 40.03,89.94 39.78,89.94 39.75,89.94 39.74,89.96 39.48,90.08 39.22,89.96 39.21,89.94 39.19,89.94 39.13,89.94 39.11,89.95 39.09,89.97 39.04,90.06 39.04,90.09 39.05,90.1 38.75,90.62 38.55,90.05 38.56,90.03 38.56,89.94 38.56,89.92 38.55,89.91 38.23,89.59 38.19,89.57 38.16,89.59 38.08,89.66 38.02,89.7 37.95,89.72 37.79,89.72 37.72,89.7 37.66,89.66 37.6,89.6 37.57,89.59 37.53,89.61 37.52,89.64 37.53,89.68 37.84,89.99 37.85,90 37.85,90.02 37.85,90.47 37.86,90.49 37.87,90.5 37.93,90.56 37.94,90.58 37.94,90.6 37.94,92.19 37.95,92.21 37.96,92.23 38.04,92.29 38.07,92.29
DGND on L03_SIG01 (solid shape): 48.32,47.82 48.34,47.78 48.35,47.75 48.34,47.73 48.29,47.54 48.35,47.36 48.36,47.33 48.36,45.45 48.37,45.43 48.38,45.42 48.96,44.83 48.97,44.82 48.98,44.79 48.97,44.7 48.95,44.68 48.94,44.68 48.88,44.16 49.4,44.22 49.4,44.23 49.42,44.24 49.51,44.25 49.54,44.25 49.56,44.24 50.09,43.7 50.1,43.69 50.11,43.67 50.11,42.33 50.1,42.3 50.08,42.28 50.06,42.28 50.03,42.28 49.84,42.48 49.82,42.49 49.8,42.49 49.69,42.49 49.67,42.49 49.65,42.47 49.63,42.44 49.6,42.42 49.56,42.43 49.55,42.44 49.29,42.56 49.04,42.44 49.02,42.43 48.99,42.42 48.95,42.44 48.93,42.47 48.92,42.49 48.89,42.49 48.46,42.49 48.42,42.51 47.66,43.27 47.65,43.29 47.64,43.31 47.64,43.91 47.65,43.93 47.66,43.95 48.1,44.39 48.11,44.4 48.11,44.42 48.11,46.61 48.11,46.63 48.1,46.65 47.62,47.13 47.61,47.14 47.6,47.17 47.64,47.21 47.65,47.22 47.67,47.23 47.86,47.32 47.95,47.51 47.96,47.53 48.25,47.82 48.27,47.83 48.3,47.83
DGND on L03_SIG01 (solid shape): 25.27,29.34 26.01,28.61 26.02,28.59 26.02,28.57 26.02,21.76 26.02,21.74 26,21.72 25.93,21.67 25.91,21.66 25.9,21.67 25.49,21.32 25.95,21.04 25.97,21.04 26.01,21.03 26.02,20.99 26.02,20.95 26.01,20.93 25.79,20.72 25.78,20.7 25.78,20.68 25.78,18.85 25.78,18.83 25.79,18.82 26.3,18.3 26.32,18.28 26.32,18.26 26.31,18.17 26.3,18.15 26.29,18.15 26.16,17.75 26.53,17.54 26.54,17.55 26.56,17.54 26.63,17.48 26.64,17.47 26.64,17.41 26.62,17.39 26.51,17.35 26.48,17.36 26.47,17.37 26.26,17.46 26.04,17.4 26.01,17.39 25.83,17.39 25.81,17.39 25.8,17.4 25.78,17.42 25.77,17.44 25.76,17.46 25.78,17.56 25.79,17.58 25.8,17.58 25.96,17.93 25.69,18.2 25.66,18.21 25.39,18.48 25.38,18.49 25.38,18.51 25.38,25.18 25.37,25.2 25.36,25.22 25.21,25.37 25.2,25.39 25.2,25.41 25.2,29.29 25.21,29.32 25.23,29.34 25.24,29.34
DGND on L03_SIG01 (solid shape): outline of 122 points within 57.49,22.81 62.43,32.38
DGND on L03_SIG01 (solid shape): 18.27,91.29 18.35,91.24 18.37,91.22 18.38,91.2 18.38,87.58 18.37,87.56 18.36,87.54 18.01,87.19 18,87.18 17.98,87.18 15.09,87.18 15.07,87.18 15.05,87.2 14.99,87.27 14.99,87.29 14.99,87.3 14.99,87.44 14.92,87.57 14.92,87.66 14.88,88.12 14.42,88.09 14.41,88.08 14.39,88.08 14.31,88.08 14.29,88.08 14.27,88.09 13.81,88.12 13.77,87.66 13.77,87.57 13.81,87.11 14.27,87.13 14.29,87.15 14.31,87.15 14.39,87.15 14.41,87.15 14.42,87.13 14.46,87.1 14.51,87.07 14.52,87.05 14.54,86.95 14.53,86.93 14.52,86.91 13.23,85.62 13.21,85.61 13.18,85.61 13.16,85.62 13.15,85.64 13.15,88.26 13.15,88.28 13.16,88.3 14.63,89.77 14.65,89.78 14.67,89.79 15.3,89.79 15.32,89.79 15.33,89.8 16.45,90.92 16.47,90.93 16.49,90.94 17.58,90.94 17.6,90.94 17.62,90.95 17.95,91.28 17.98,91.29 17.99,91.28 18.11,91.26 18.23,91.29 18.25,91.3
DGND on L03_SIG01 (solid shape): 28.13,82.18 28.16,82.18 28.18,82.17 28.63,81.72 28.64,81.7 28.64,81.68 28.64,78.58 28.64,78.55 28.62,78.54 28.54,78.48 28.52,78.48 28.51,78.48 28.07,78.17 28.51,77.86 28.52,77.86 28.54,77.86 28.62,77.8 28.64,77.79 28.64,77.76 28.64,77.66 28.64,77.64 28.62,77.62 28.54,77.57 28.52,77.56 28.51,77.57 28.07,77.26 28.51,76.94 28.52,76.95 28.54,76.94 28.62,76.89 28.64,76.87 28.64,76.85 28.64,76.23 28.64,76.21 28.63,76.19 27.95,75.52 27.93,75.5 27.9,75.51 27.88,75.51 27.87,75.54 27.87,80.05 27.87,80.07 27.88,80.09 27.95,80.15 27.98,80.15 28.36,80.48 27.98,80.81 27.95,80.81 27.88,80.87 27.87,80.89 27.87,80.91 27.87,81.35 27.86,81.37 27.85,81.39 27.42,81.82 27.41,81.83 27.41,81.87 27.42,81.9 27.44,81.92 27.46,81.93 27.49,81.93 27.51,81.93 27.81,81.9 28.01,82.12 28.01,82.14 28.03,82.16
DGND on L03_SIG01 (solid shape): 10.68,76.79 10.94,76.52 10.96,76.51 10.97,76.51 12.44,76.51 12.46,76.51 12.48,76.49 13.46,75.51 13.48,75.5 13.5,75.49 15.87,75.49 15.89,75.49 15.9,75.48 15.98,75.4 15.99,75.38 15.99,75.35 15.97,75.26 15.95,75.24 15.94,75.23 15.83,75.18 15.75,75.1 15.74,75.09 15.71,75.08 15.63,75.08 15.6,75.09 15.59,75.1 14.98,74.91 15.59,74.73 15.6,74.74 15.63,74.75 15.71,74.75 15.74,74.74 15.76,74.72 15.77,74.69 15.76,74.66 15.73,74.32 16.01,74.13 16.03,74.13 16.05,74.11 16.09,74.01 16.09,73.98 16.08,73.95 15.95,73.83 15.94,73.82 15.92,73.81 14.78,73.81 14.76,73.82 14.74,73.84 14.69,73.92 14.69,73.95 14.7,73.96 14.32,74.45 14.25,73.84 14.26,73.83 14.27,73.81 14.29,73.72 14.29,73.7 14.27,73.68 13.33,72.73 13.3,72.72 13.27,72.72 13.26,72.72 13.24,72.75 13.24,73.57 13.24,73.59 13.23,73.6 10.62,76.21 10.61,76.23 10.6,76.25 10.6,76.74 10.61,76.77 10.63,76.79 10.65,76.79
DGND on L03_SIG01 (solid shape): outline of 132 points within 59.16,22.85 64.8,29.72
DGND on L03_SIG01 (solid shape): outline of 145 points within 52.64,26.85 56.11,38.34
DGND on L03_SIG01 (solid shape): outline of 162 points within 21.29,33.42 23.61,40.7
DGND on L03_SIG01 (solid shape): outline of 99 points within 24.27,40.12 27.89,56.14
DGND on L03_SIG01 (solid shape): outline of 182 points within 19.05,101.04 24.54,103.7
DGND on L03_SIG01 (solid shape): outline of 100 points within 1.03,37.39 13.79,67.2
DGND on L03_SIG01 (solid shape): outline of 209 points within 58.26,122.76 65.68,126.06
DGND on L03_SIG01 (solid shape): outline of 224 points within 1.72,80.72 7.47,87.76
DGND on L03_SIG01 (solid shape): outline of 123 points within 44.62,96.34 49.56,99.22
DGND on L03_SIG01 (solid shape): outline of 271 points within 13.21,96.56 15.9,101.86
DGND on L03_SIG01 (solid shape): outline of 290 points within 66.55,17.83 72.39,25.26
DGND on L03_SIG01 (solid shape): outline of 354 points within 9.29,64.85 12.5,83.31
DGND on L03_SIG01 (solid shape): outline of 366 points within 23.19,65.34 27.36,83.91
DGND on L03_SIG01 (solid shape): outline of 365 points within 9.61,110.17 11.99,120.52
DGND on L03_SIG01 (solid shape): outline of 171 points within 23.49,51.05 25.78,64.18
DGND on L03_SIG01 (solid shape): outline of 569 points within 46.92,50.18 53.42,60.19
DGND on L03_SIG01 (solid shape): outline of 486 points within 30.96,22.42 37.21,59.8
DGND on L03_SIG01 (solid shape): outline of 622 points within 17.22,37.15 22.06,53.91
DGND on L03_SIG01 (solid shape): outline of 579 points within 13.49,54.04 22.38,73.9
DGND on L03_SIG01 (solid shape): outline of 631 points within 46.68,21.31 57.76,29.23
DGND on L03_SIG01 (solid shape): outline of 697 points within 25.9,23.91 30.23,38.1
DGND on L03_SIG01 (solid shape): outline of 817 points within 65.8,105.11 74.14,127.04
DGND on L03_SIG01 (solid shape): outline of 768 points within 48.65,101.32 67.37,123.31
DGND on L03_SIG01 (solid shape): outline of 887 points within 2.3,58.83 14.29,93.94
DGND on L03_SIG01 (solid shape): outline of 1042 points within 2.01,93.89 14.76,106.6
DGND on L03_SIG01 (solid shape): outline of 1029 points within 30.96,14.76 55.81,21.47
DGND on L03_SIG01 (solid shape): outline of 912 points within 11.06,75.85 36.16,103.42
DGND on L03_SIG01 (solid shape): outline of 1130 points within 62.05,80.3 84.36,109.38
DGND on L03_SIG01 (solid shape): outline of 1031 points within 54.74,88.46 69.7,104.56
DGND on L03_SIG01 (solid shape): outline of 1123 points within 18.14,65.24 26.67,94.31
DGND on L03_SIG01 (solid shape): outline of 1503 points within 28.41,92.93 44.76,102.18
DGND on L03_SIG01 (solid shape): outline of 1817 points within 31.97,18.66 53.04,41.77
DGND on L03_SIG01 (solid shape): outline of 3478 points within 18.88,87.45 46.37,113.05
DGND on L03_SIG01 (solid shape): outline of 4189 points within 0.64,5.71 28.69,60.25
DGND on L03_SIG01 (solid shape): outline of 17096 points within 0.63,91.25 84.36,154.54
DGND on L03_SIG01 (solid shape): outline of 20569 points within 25.77,5.71 84.36,99.72
DGND on L05_SIG02 (solid shape): 1.62,91.77 1.65,91.78 1.68,91.78 1.69,91.77 1.71,91.75 1.71,90.82 1.71,90.8 1.7,90.79 1.12,90.21 1.09,90.19 1.06,90.19 1.05,90.2 1.03,90.23 1.03,91.15 1.03,91.17 1.04,91.19
DGND on L05_SIG02 (solid shape): 9.75,78.23 9.77,78.25 9.8,78.24 9.82,78.24 9.83,78.21 9.83,77.89 9.83,77.87 9.82,77.85 8.07,76.1 8.04,76.09 8.01,76.09 8,76.1 7.98,76.12 7.98,76.45 7.98,76.46 7.99,76.48
DGND on L05_SIG02 (solid shape): 9.94,84.88 9.97,84.89 10,84.89 10.01,84.88 10.03,84.86 10.03,82.1 10.03,82.08 10.02,82.07 9.65,81.69 9.62,81.68 9.59,81.68 9.58,81.69 9.56,81.72 9.56,84.47 9.56,84.49 9.57,84.5
DGND on L05_SIG02 (solid shape): 10,67.1 10.32,66.79 10.33,66.77 10.33,66.75 10.33,62.06 10.32,62.03 10.3,62.01 10.29,62.01 10.26,62.01 9.94,62.33 9.93,62.35 9.93,62.37 9.93,67.05 9.93,67.08 9.96,67.1 9.97,67.11
DGND on L05_SIG02 (solid shape): 10.11,54.37 10.13,54.37 10.15,54.35 10.44,54.06 10.45,54.04 10.45,54.01 10.44,53.99 10.42,53.98 7.18,53.98 7.16,53.98 7.14,53.99 6.85,54.28 6.84,54.31 6.84,54.34 6.85,54.35 6.87,54.37
DGND on L05_SIG02 (solid shape): 12.69,110.01 12.72,110.02 12.75,110.02 12.76,110.01 12.78,109.99 12.78,109.31 12.77,109.29 12.76,109.27 11.89,108.4 11.86,108.39 11.84,108.39 11.82,108.4 11.8,108.42 11.8,109.1 11.81,109.12 11.82,109.13
DGND on L05_SIG02 (solid shape): 13.1,53.23 13.4,52.93 13.41,52.92 13.41,52.9 13.41,40.11 13.4,40.08 13.38,40.06 13.37,40.05 13.34,40.06 13.04,40.36 13.03,40.37 13.02,40.39 13.02,53.18 13.03,53.21 13.06,53.23 13.07,53.24
DGND on L05_SIG02 (solid shape): 20.22,53.99 20.24,53.98 20.26,53.97 20.52,53.71 20.54,53.68 20.53,53.65 20.53,53.64 20.5,53.62 17.96,53.62 17.94,53.63 17.92,53.64 17.66,53.9 17.64,53.93 17.65,53.96 17.65,53.97 17.68,53.99
DGND on L05_SIG02 (solid shape): 20.44,52.86 20.46,52.86 20.47,52.84 20.74,52.58 20.76,52.55 20.75,52.52 20.75,52.51 20.72,52.49 18.29,52.49 18.27,52.49 18.25,52.51 17.99,52.77 17.97,52.8 17.98,52.83 17.98,52.84 18.01,52.86
DGND on L05_SIG02 (solid shape): 22.94,55.66 22.96,55.66 22.98,55.65 23.65,54.98 23.66,54.96 23.66,54.94 23.66,54.4 23.65,54.37 23.63,54.35 23.62,54.35 23.59,54.35 22.36,55.58 22.35,55.6 22.35,55.63 22.36,55.65 22.38,55.66
DGND on L05_SIG02 (solid shape): 26.42,100.07 26.45,100.06 26.47,100.04 26.47,100.02 26.47,99.99 24.85,98.38 24.82,98.36 24.8,98.37 24.78,98.37 24.76,98.4 24.76,98.84 24.77,98.86 24.78,98.88 25.95,100.05 25.97,100.06 25.99,100.07
DGND on L05_SIG02 (solid shape): 27.12,46.07 27.4,45.79 27.41,45.78 27.41,45.76 27.41,42.28 27.4,42.26 27.38,42.24 27.37,42.23 27.34,42.24 27.06,42.52 27.05,42.53 27.04,42.55 27.04,46.02 27.05,46.05 27.07,46.07 27.09,46.08
DGND on L05_SIG02 (solid shape): 27.25,52.94 27.26,52.93 27.28,52.92 28.07,52.14 28.08,52.11 28.08,52.08 28.07,52.07 28.05,52.05 25.46,52.05 25.44,52.05 25.43,52.06 24.64,52.85 24.63,52.88 24.63,52.91 24.63,52.92 24.66,52.94
DGND on L05_SIG02 (solid shape): 61,97.94 61.03,97.95 61.06,97.95 61.07,97.95 61.09,97.92 61.09,92.39 61.09,92.37 61.07,92.36 60.67,91.95 60.64,91.94 60.61,91.94 60.6,91.95 60.58,91.97 60.58,97.5 60.59,97.52 60.6,97.54
DGND on L05_SIG02 (solid shape): 66.81,140.03 66.83,140.02 66.84,140.01 67.96,138.9 67.97,138.88 67.97,138.86 67.97,138.18 67.96,138.15 67.94,138.13 67.93,138.12 67.9,138.13 66.09,139.94 66.07,139.97 66.07,140 66.08,140.01 66.11,140.03
DGND on L05_SIG02 (solid shape): 69.21,136.61 69.53,136.29 69.54,136.27 69.55,136.25 69.55,132.64 69.54,132.61 69.52,132.59 69.5,132.58 69.47,132.59 69.15,132.91 69.14,132.93 69.14,132.95 69.14,136.56 69.14,136.59 69.17,136.61 69.18,136.61
DGND on L05_SIG02 (solid shape): 28.24,40.61 28.88,39.97 28.9,39.95 28.9,39.93 28.9,38.8 28.88,38.76 28.85,38.75 28.76,38.77 28.18,39.35 28.17,39.37 28.16,39.39 28.16,40.57 28.17,40.6 28.2,40.61 28.21,40.62
DGND on L05_SIG02 (solid shape): 49.66,44.14 49.68,44.14 49.7,44.13 50.94,42.88 50.95,42.87 50.95,42.85 50.95,42.33 50.95,42.3 50.92,42.28 50.91,42.27 50.88,42.28 49.23,43.93 49.21,43.95 49.21,43.98 49.23,44.07 49.24,44.09 49.29,44.11 49.34,44.14
DGND on L05_SIG02 (solid shape): 63.22,99.88 63.3,99.89 63.32,99.88 63.38,99.82 63.4,99.81 63.4,99.78 63.4,91.91 63.39,91.88 63.37,91.86 63.35,91.86 63.32,91.86 63.04,92.15 63.02,92.17 63.02,92.19 63.02,99.8 63.03,99.82 63.04,99.84 63.12,99.89 63.14,99.9
DGND on L05_SIG02 (solid shape): 29.15,121.23 29.17,121.23 29.19,121.22 29.55,120.86 29.56,120.83 29.56,120.8 29.55,120.79 29.53,120.77 26.7,120.77 26.68,120.78 26.66,120.8 26.61,120.87 26.6,120.9 26.61,120.91 26.63,121.01 26.62,121.1 26.61,121.12 26.62,121.14 26.67,121.21 26.69,121.23 26.71,121.23
DGND on L05_SIG02 (solid shape): 7.38,67.87 7.41,67.88 7.44,67.88 7.45,67.87 7.47,67.85 7.47,67.65 7.47,67.63 7.45,67.62 7.21,67.37 7.2,67.36 7.2,67.34 7.2,61.29 7.19,61.26 7.17,61.24 7.15,61.23 7.12,61.24 6.96,61.4 6.95,61.42 6.94,61.44 6.94,67.41 6.95,67.43 6.96,67.44
DGND on L05_SIG02 (solid shape): 9.04,89.76 9.07,89.77 9.1,89.77 9.11,89.77 9.13,89.74 9.13,88.75 9.13,88.73 9.12,88.71 8.61,88.2 8.6,88.18 8.59,88.16 8.59,87.78 8.58,87.75 8.56,87.73 8.55,87.73 8.52,87.73 8.25,88 8.24,88.02 8.23,88.04 8.23,88.93 8.24,88.95 8.25,88.96
DGND on L05_SIG02 (solid shape): 9.71,75.71 9.74,75.72 9.77,75.72 9.78,75.71 9.8,75.69 9.8,74.66 9.8,74.64 9.79,74.62 9.41,74.25 9.4,74.23 9.4,74.21 9.4,67.71 9.39,67.68 9.37,67.66 9.35,67.65 9.32,67.66 9.16,67.82 9.15,67.84 9.14,67.86 9.14,75.12 9.15,75.14 9.16,75.15
DGND on L05_SIG02 (solid shape): 11.61,55.49 11.63,55.48 11.65,55.47 12.51,54.61 12.52,54.58 12.52,54.55 12.51,54.54 12.49,54.52 11.15,54.52 11.13,54.53 11.12,54.54 10.51,55.14 10.49,55.15 10.48,55.16 8.5,55.16 8.48,55.16 8.46,55.17 8.23,55.4 8.22,55.43 8.22,55.46 8.23,55.47 8.25,55.49
DGND on L05_SIG02 (solid shape): 15.72,61.3 16.1,60.91 16.12,60.9 16.14,60.9 16.51,60.9 16.53,60.89 16.55,60.88 18.31,59.12 18.33,59.09 18.32,59.06 18.32,59.05 18.29,59.03 17.82,59.03 17.8,59.03 17.78,59.05 15.66,61.16 15.65,61.18 15.65,61.2 15.65,61.25 15.65,61.28 15.68,61.3 15.69,61.3
DGND on L05_SIG02 (solid shape): 15.75,53.55 15.88,53.42 15.9,53.41 15.92,53.4 16.62,53.4 16.63,53.4 16.65,53.39 17.16,52.88 17.17,52.86 17.17,52.83 17.16,52.81 17.14,52.8 16.16,52.8 16.14,52.8 16.12,52.81 15.69,53.24 15.68,53.26 15.67,53.28 15.67,53.51 15.68,53.53 15.71,53.55 15.72,53.56
DGND on L05_SIG02 (solid shape): 16.55,108.84 16.58,108.85 16.61,108.85 16.62,108.85 16.64,108.82 16.63,108.78 16.62,108.77 15.31,107.45 15.3,107.44 15.29,107.42 15.29,106.09 15.29,106.07 15.28,106.05 13.82,104.6 13.8,104.58 13.77,104.59 13.75,104.59 13.73,104.62 13.73,106 13.74,106.02 13.75,106.04
DGND on L05_SIG02 (solid shape): 18.15,37.15 18.17,37.16 18.2,37.16 18.22,37.15 18.23,37.13 18.23,36.48 18.23,36.46 18.22,36.44 17.89,36.11 17.87,36.1 17.85,36.1 16.37,36.1 16.34,36.1 16.32,36.13 16.32,36.14 16.32,36.17 16.92,36.77 16.94,36.78 16.96,36.79 17.77,36.79 17.79,36.79 17.8,36.8
DGND on L05_SIG02 (solid shape): 20.36,104.98 20.38,104.95 20.38,104.94 20.38,104.91 19.59,104.12 19.58,104.11 19.58,104.09 19.58,103.84 19.57,103.83 19.56,103.81 19.03,103.28 19.02,103.27 19,103.27 18.71,103.27 18.68,103.27 18.66,103.3 18.66,103.31 18.66,103.34 20.29,104.97 20.31,104.98
DGND on L05_SIG02 (solid shape): 54.61,34.05 54.63,34.05 54.65,34.03 56.45,32.23 56.46,32.21 56.46,32.18 56.45,32.16 56.43,32.15 56.38,32.15 56.36,32.15 56.35,32.16 55.64,32.87 55.63,32.88 55.61,32.88 55.3,32.88 55.28,32.88 55.26,32.9 54.19,33.96 54.18,33.99 54.18,34.02 54.19,34.03 54.21,34.05
DGND on L05_SIG02 (solid shape): 64.35,108.68 64.37,108.69 64.4,108.69 64.42,108.68 64.43,108.66 64.43,105.34 64.43,105.32 64.42,105.3 64.14,105.02 64.11,105.01 64.08,105.01 64.07,105.02 64.05,105.04 64.05,105.44 64.05,105.46 64.04,105.48 63.34,106.17 63.33,106.19 63.33,106.21 63.33,107.64 63.33,107.65 63.34,107.67
DGND on L05_SIG02 (solid shape): 36.86,46.39 38.61,44.64 38.61,44.62 38.6,44.54 38.58,44.51 38.48,44.48 38.45,44.47 38.43,44.49 38.09,44.83 38.07,44.84 38.05,44.84 37.37,44.84 37.35,44.84 37.34,44.85 36.8,45.4 36.79,45.41 36.78,45.43 36.78,46.34 36.79,46.37 36.81,46.39 36.83,46.4
DGND on L05_SIG02 (solid shape): 71.54,128.38 71.56,128.36 71.57,128.33 71.57,124.77 71.57,124.75 71.56,124.73 71.09,124.27 71.07,124.26 71.04,124.26 71.02,124.27 71,124.29 71,128.21 71.01,128.23 71.02,128.25 71.09,128.3 71.11,128.31 71.12,128.31 71.27,128.32 71.4,128.4 71.41,128.41 71.44,128.42
DGND on L05_SIG02 (solid shape): 21.9,57.7 21.92,57.69 21.93,57.68 22.47,57.15 22.48,57.12 22.48,57.09 22.47,57.08 22.45,57.06 20.09,57.06 20.07,57.07 20.05,57.08 20,57.16 19.99,57.18 20,57.19 20,57.37 19.91,57.52 19.9,57.53 19.9,57.56 19.94,57.67 19.96,57.69 19.99,57.7
DGND on L05_SIG02 (solid shape): 13.14,124.4 13.17,124.39 13.17,124.3 12.27,123.4 12.26,123.39 12.24,123.38 12.01,123.38 11.99,123.38 11.97,123.37 11.21,122.61 11.19,122.6 11.16,122.6 11.15,122.6 11.13,122.63 11.13,123.39 11.13,123.41 11.14,123.42 12.11,124.39 12.12,124.4 12.14,124.4
DGND on L05_SIG02 (solid shape): 25.91,112.25 25.93,112.25 25.95,112.24 27.13,111.05 27.15,111.02 27.14,110.99 27.14,110.98 27.11,110.96 26.72,110.96 26.7,110.97 26.68,110.98 25.75,111.91 25.73,111.92 25.71,111.93 25.68,111.96 25.71,112.07 25.73,112.18 25.79,112.24 25.81,112.25 25.83,112.25
DGND on L05_SIG02 (solid shape): 25.23,97.34 25.31,97.33 25.37,97.27 25.39,97.25 25.39,97.23 25.39,96.27 25.39,96.25 25.37,96.23 24.45,95.3 24.42,95.29 24.39,95.29 24.38,95.3 24.36,95.32 24.36,96.46 24.37,96.48 24.38,96.5 25.04,97.16 25.05,97.17 25.05,97.19 25.05,97.25 25.06,97.27 25.07,97.29 25.14,97.34 25.17,97.35
DGND on L05_SIG02 (solid shape): 63.18,87.45 63.54,87.1 63.55,87.08 63.55,87.06 63.55,83.88 63.55,83.86 63.53,83.84 63.47,83.78 63.44,83.78 63.38,83.78 63.31,83.78 63.29,83.78 63.22,83.84 63.2,83.86 63.2,83.88 63.2,84.62 63.19,84.64 63.18,84.66 63.12,84.72 63.11,84.73 63.11,84.75 63.11,87.4 63.12,87.43 63.14,87.45 63.16,87.46
DGND on L05_SIG02 (solid shape): 9.24,67.02 9.4,66.86 9.41,66.84 9.42,66.82 9.42,62.15 9.42,62.14 9.43,62.12 9.68,61.88 9.69,61.86 9.69,61.84 9.68,61.75 9.67,61.73 9.66,61.72 9.6,61.67 9.56,61.6 9.55,61.59 9.53,61.58 9.44,61.56 9.42,61.57 9.4,61.58 9.18,61.8 9.17,61.81 9.16,61.83 9.16,66.98 9.17,67 9.2,67.02 9.21,67.03
DGND on L05_SIG02 (solid shape): 60.1,21.48 60.12,21.47 60.14,21.46 60.19,21.39 60.2,21.36 60.19,21.28 60.2,21.19 60.19,21.17 60.13,21.1 60.12,21.08 60.07,21.07 60.05,21.06 59.99,21 59.97,20.99 59.95,20.99 56.83,20.99 56.81,20.99 56.8,21 56.41,21.39 56.39,21.42 56.4,21.45 56.4,21.46 56.43,21.48
DGND on L05_SIG02 (solid shape): 26.21,48.37 26.23,48.37 26.26,48.36 28.35,46.26 28.36,46.25 28.37,46.23 28.37,41.79 28.36,41.76 28.34,41.74 28.32,41.73 28.29,41.74 27.94,42.1 27.93,42.11 27.92,42.13 27.92,45.97 27.92,45.99 27.91,46 25.91,48 25.9,48.02 25.9,48.04 25.91,48.13 25.93,48.15 25.94,48.16 26.03,48.23 26.09,48.33 26.09,48.34 26.11,48.35
DGND on L05_SIG02 (solid shape): 50.57,39.19 50.98,38.78 50.99,38.76 51,38.74 51,37.61 51,37.59 51.01,37.57 51.16,37.42 51.17,37.4 51.18,37.38 51.17,37.29 51.16,37.27 51.15,37.26 51.08,37.2 51.03,37.12 51.03,37.11 51.01,37.09 50.91,37.08 50.89,37.08 50.87,37.09 50.51,37.45 50.5,37.46 50.49,37.48 50.49,39.14 50.5,39.17 50.53,39.19 50.54,39.19
DGND on L05_SIG02 (solid shape): 10.25,53.47 10.27,53.46 10.29,53.45 11.55,52.19 11.56,52.18 11.56,52.16 11.56,40.01 11.55,39.99 11.53,39.97 11.52,39.96 11.49,39.97 11.12,40.34 11.11,40.35 11.1,40.37 11.1,50.21 11.1,50.23 11.09,50.25 10,51.34 9.99,51.35 9.99,51.37 9.99,53.06 9.98,53.08 9.97,53.09 9.68,53.38 9.67,53.41 9.67,53.44 9.68,53.45 9.7,53.47
DGND on L05_SIG02 (solid shape): 11.76,119.12 11.79,119.11 11.81,119.07 11.81,118.89 11.83,118.8 11.88,118.71 12.01,118.59 12.03,118.56 12.02,118.53 12.02,118.52 11.99,118.5 11.48,118.5 11.46,118.49 11.44,118.48 8.78,115.82 8.75,115.8 8.72,115.81 8.71,115.81 8.69,115.84 8.69,116.41 8.69,116.43 8.7,116.44 11.37,119.11 11.39,119.12 11.41,119.12
DGND on L05_SIG02 (solid shape): 12.25,53.66 12.27,53.65 12.28,53.64 12.5,53.42 12.51,53.41 12.52,53.39 12.52,40.18 12.52,40.16 12.53,40.15 14.1,38.58 14.11,38.56 14.11,38.53 14.1,38.51 14.08,38.5 13.44,38.5 13.42,38.5 13.4,38.51 12.09,39.83 12.08,39.84 12.07,39.86 12.07,52.37 12.07,52.39 12.06,52.4 10.89,53.57 10.87,53.6 10.88,53.63 10.88,53.64 10.91,53.66
DGND on L05_SIG02 (solid shape): 42.3,37.53 42.32,37.52 42.33,37.51 43.78,36.07 43.79,36.05 43.79,36.03 43.79,35.71 43.8,35.69 43.81,35.67 46.38,33.1 46.39,33.07 46.39,33.04 46.39,33.03 46.36,33.01 46.08,33.01 46.06,33.01 46.04,33.02 42.29,36.78 42.27,36.79 42.25,36.79 41.58,36.79 41.56,36.8 41.55,36.81 40.91,37.44 40.9,37.47 40.9,37.5 40.91,37.51 40.93,37.53
DGND on L05_SIG02 (solid shape): 44.71,91.44 44.73,91.44 44.74,91.43 45.67,90.51 45.68,90.49 45.68,90.47 45.68,90.22 45.67,90.19 45.65,90.18 45.64,90.17 45.61,90.18 45.32,90.46 45.31,90.48 45.3,90.5 45.3,90.58 45.3,90.6 45.29,90.62 44.62,91.29 44.6,91.3 44.59,91.3 42.77,91.3 42.75,91.3 42.74,91.32 42.7,91.36 42.68,91.38 42.68,91.41 42.69,91.43 42.72,91.44
DGND on L05_SIG02 (solid shape): 61.78,146.51 61.8,146.5 61.81,146.49 66.35,141.95 66.36,141.94 66.38,141.94 66.85,141.94 66.87,141.94 66.88,141.93 67.29,141.52 67.3,141.5 67.3,141.48 67.3,140.92 67.31,140.9 67.32,140.88 67.35,140.85 67.36,140.83 67.36,140.8 67.35,140.78 67.33,140.76 66.69,140.76 66.67,140.77 66.65,140.78 61.02,146.42 61,146.44 61,146.47 61.01,146.49 61.04,146.51
DGND on L05_SIG02 (solid shape): 65.84,115.2 65.87,115.22 65.9,115.22 65.91,115.21 65.93,115.18 65.93,112.56 65.93,112.54 65.95,112.52 66.25,112.22 66.26,112.2 66.26,112.18 66.26,111.45 66.27,111.43 66.28,111.41 66.55,111.14 66.56,111.12 66.57,111.11 66.57,109.27 66.56,109.24 66.53,109.22 66.52,109.22 66.49,109.22 65.82,109.89 65.81,109.91 65.8,109.93 65.8,115.14 65.81,115.16 65.82,115.18
DGND on L05_SIG02 (solid shape): 66.76,78.04 67.07,77.74 67.08,77.72 67.08,77.7 67.08,69.1 67.08,69.08 67.07,69.07 66.36,68.36 66.35,68.34 66.35,68.32 66.35,67.27 66.34,67.24 66.32,67.23 66.3,67.22 66.27,67.23 65.71,67.79 65.7,67.81 65.69,67.83 65.69,72.74 65.7,72.76 65.71,72.78 66.67,73.74 66.68,73.76 66.69,73.78 66.69,78 66.7,78.02 66.72,78.04 66.73,78.05
DGND on L05_SIG02 (solid shape): 66.78,46.43 66.81,46.45 66.84,46.44 66.85,46.44 66.87,46.41 66.87,46.33 66.87,46.31 66.86,46.3 63,42.44 62.98,42.43 62.96,42.42 62.76,42.42 62.74,42.43 62.72,42.44 62.39,42.76 62.38,42.78 62.36,42.78 61.46,42.78 61.43,42.79 61.41,42.81 61.41,42.82 61.41,42.85 61.61,43.05 61.63,43.06 61.65,43.07 63.4,43.07 63.41,43.07 63.43,43.08
DGND on L05_SIG02 (solid shape): 59.43,71.61 59.52,71.56 59.53,71.54 59.54,71.51 59.54,68.41 59.54,68.39 59.52,68.37 57.65,66.49 57.62,66.48 57.59,66.48 57.58,66.49 57.56,66.51 57.56,67.65 57.56,67.67 57.57,67.69 58.97,69.08 58.98,69.1 58.98,69.12 58.98,71.49 58.99,71.51 59,71.53 59.08,71.59 59.11,71.59 59.12,71.59 59.26,71.56 59.39,71.6 59.4,71.61
DGND on L05_SIG02 (solid shape): 27.27,70.05 27.85,69.47 27.86,69.45 27.87,69.43 27.87,66.1 27.86,66.08 27.83,66.06 27.82,66.05 27.79,66.06 27.71,66.13 27.71,66.16 27.71,66.18 27.7,66.47 27.46,66.63 27.43,66.64 27.21,66.87 27.2,66.88 27.19,66.9 27.19,70 27.2,70.03 27.22,70.05 27.24,70.06
DGND on L05_SIG02 (solid shape): 61.47,107.79 61.61,107.75 61.76,107.78 61.77,107.79 61.79,107.79 61.88,107.74 61.9,107.72 61.9,107.69 61.9,103.82 61.89,103.8 61.87,103.78 61.86,103.77 61.83,103.78 61.59,104.02 61.58,104.03 61.57,104.05 61.57,107.46 61.57,107.48 61.56,107.5 61.41,107.65 61.4,107.66 61.39,107.68 61.39,107.74 61.41,107.78 61.45,107.79
DGND on L05_SIG02 (solid shape): 42.81,97.39 42.81,95.27 42.81,95.25 42.82,95.23 43.51,94.54 43.53,94.49 43.51,94.45 43.48,94.44 43.18,94.44 43.16,94.43 43.15,94.42 43.04,94.32 43.01,94.3 42.98,94.3 42.97,94.31 42.95,94.34 42.95,94.44 42.95,94.46 42.94,94.48 42.57,94.85 42.56,94.86 42.55,94.88 42.55,97.34 42.57,97.38 42.6,97.39 42.8,97.39
DGND on L05_SIG02 (solid shape): 53.02,88.62 53.05,88.64 53.09,88.62 54.32,87.39 54.33,87.38 54.33,87.36 54.33,87.31 54.32,87.27 54.28,87.26 54.27,87.26 54.24,87.28 54.21,87.34 54.18,87.37 54,87.55 53.99,87.56 53.97,87.56 52.85,87.56 52.85,87.57 52.85,88.34 52.84,88.36 52.83,88.38 52.81,88.4 52.8,88.42 52.8,88.45 52.81,88.47 52.83,88.48 52.86,88.48 52.88,88.49 52.89,88.5
DGND on L05_SIG02 (solid shape): 59.35,126.52 59.37,126.52 59.39,126.51 60.17,125.72 60.19,125.71 60.21,125.71 60.3,125.71 60.33,125.7 60.35,125.68 60.39,125.58 60.39,125.55 60.38,125.54 60.3,125.36 60.34,125.17 60.35,125.16 60.35,125.14 60.29,125.05 60.28,125.03 60.22,125.03 60.21,125.04 58.81,126.44 58.8,126.46 58.8,126.49 58.8,126.51 58.83,126.52
DGND on L05_SIG02 (solid shape): 8.08,62.07 8.1,62.06 8.2,62.02 8.31,62 8.34,62 8.4,61.94 8.41,61.92 8.41,61.9 8.41,61.37 8.42,61.35 8.43,61.33 9.77,60 9.78,59.97 9.78,59.95 9.76,59.85 9.74,59.83 9.73,59.83 9.66,59.79 9.59,59.73 9.57,59.71 9.48,59.7 9.46,59.71 9.44,59.72 7.95,61.21 7.94,61.23 7.93,61.25 7.93,61.98 7.94,62.01 7.96,62.03 8.06,62.07
DGND on L05_SIG02 (solid shape): 23.08,104.4 23.11,104.39 23.12,104.37 23.13,104.35 23.12,104.32 21.73,102.93 21.71,102.92 21.69,102.91 21.21,102.91 21.19,102.91 21.16,102.88 21.12,102.87 21.09,102.88 21.07,102.92 21.05,103.02 21.01,103.1 21,103.11 21,103.14 21.05,103.24 21.07,103.26 21.09,103.26 21.62,103.26 21.64,103.27 21.66,103.28 22.76,104.38 22.78,104.39 22.8,104.4
DGND on L05_SIG02 (solid shape): 46.75,120.9 46.78,120.89 46.8,120.87 46.8,120.85 46.8,120.83 46.6,120.62 46.59,120.61 46.58,120.59 46.58,120.34 46.58,120.32 46.57,120.3 46.45,120.18 46.43,120.17 46.41,120.16 44.79,120.16 44.76,120.17 44.75,120.19 44.74,120.21 44.75,120.24 44.79,120.28 44.8,120.3 44.81,120.32 44.81,120.42 44.82,120.46 44.86,120.47 46.1,120.47 46.12,120.48 46.13,120.49 46.53,120.89 46.55,120.9 46.57,120.9
DGND on L05_SIG02 (solid shape): 55.78,44.87 56.15,44.5 56.16,44.48 56.16,44.46 56.16,41.46 56.17,41.44 56.18,41.42 57.15,40.45 57.17,40.42 57.16,40.38 57.09,40.19 57.15,40 57.16,39.99 57.16,39.96 57.11,39.87 57.1,39.85 57.04,39.85 57.02,39.86 55.72,41.16 55.71,41.18 55.71,41.2 55.71,44.82 55.71,44.85 55.74,44.87 55.75,44.87
DGND on L05_SIG02 (solid shape): 17.9,102.05 17.92,102.07 17.94,102.07 18.03,102.06 18.05,102.04 18.06,102.03 18.23,101.88 18.45,101.87 18.47,101.88 18.49,101.87 18.57,101.82 18.58,101.8 18.59,101.77 18.59,101.65 18.58,101.63 18.57,101.61 18.08,101.12 18.07,101.11 18.05,101.11 17.4,101.11 17.38,101.1 17.36,101.09 17.09,100.83 17.07,100.81 17.04,100.82 17.02,100.82 17.01,100.85 17.01,101.14 17.01,101.16 17.02,101.18
DGND on L05_SIG02 (solid shape): 44.76,33.21 45.07,32.89 45.08,32.88 45.09,32.86 45.09,31.23 45.08,31.21 45.07,31.19 44.82,30.94 44.8,30.93 44.78,30.93 43.33,30.93 43.31,30.92 43.29,30.91 41.64,29.26 41.63,29.25 41.58,29.25 41.55,29.26 41.53,29.28 41.53,29.29 41.53,29.32 43.63,31.42 43.65,31.43 43.66,31.43 44.21,31.43 44.23,31.44 44.24,31.45 44.67,31.87 44.68,31.89 44.68,31.91 44.68,33.16 44.69,33.19 44.71,33.21 44.73,33.21
DGND on L05_SIG02 (solid shape): 28.31,53.17 28.33,53.16 28.34,53.15 29.04,52.45 29.06,52.44 29.08,52.44 32.25,52.44 32.27,52.44 32.28,52.42 38.27,46.44 38.28,46.42 38.29,46.4 38.28,46.31 38.26,46.28 38.18,46.18 38.14,46.06 38.14,46.05 38.12,46.02 38.02,45.99 37.99,45.98 37.97,46 34.18,49.78 34.17,49.79 34.15,49.8 31.15,49.8 31.13,49.8 31.11,49.81 27.84,53.08 27.83,53.11 27.83,53.13 27.84,53.15 27.86,53.17
DGND on L05_SIG02 (solid shape): 29.08,105.84 29.11,105.83 29.13,105.81 29.13,105.8 29.13,105.77 28.51,105.15 28.5,105.14 28.48,105.14 28.27,105.14 28.25,105.14 28.23,105.15 28.18,105.22 28.17,105.25 28,105.57 27.64,105.54 27.61,105.53 22.68,105.53 22.66,105.54 22.64,105.56 22.63,105.58 22.64,105.61 22.86,105.83 22.87,105.84 22.89,105.84
DGND on L05_SIG02 (solid shape): 58.1,146.71 58.12,146.7 58.14,146.69 59.04,145.79 59.06,145.78 59.08,145.77 60.3,145.77 60.31,145.77 60.33,145.76 61.17,144.92 61.18,144.89 61.18,144.86 61.18,144.85 61.15,144.83 59.75,144.83 59.73,144.84 59.71,144.85 58.46,146.1 58.44,146.11 58.42,146.11 57.58,146.11 57.56,146.12 57.54,146.15 57.49,146.25 57.5,146.28 57.51,146.29 57.59,146.42 57.6,146.58 57.59,146.6 57.6,146.62 57.66,146.69 57.67,146.7 57.69,146.71
DGND on L05_SIG02 (solid shape): 70.13,136.28 70.79,135.62 70.8,135.6 70.81,135.58 70.81,132.15 70.81,132.13 70.82,132.12 71.56,131.38 71.57,131.37 71.57,131.35 71.57,129.65 71.56,129.63 71.54,129.61 71.44,129.56 71.41,129.57 71.4,129.58 71.27,129.66 71.12,129.67 71.11,129.67 71.09,129.68 71.02,129.74 71.01,129.75 71,129.78 71,131.74 71,131.76 70.99,131.78 70.07,132.7 70.06,132.72 70.06,132.73 70.06,136.23 70.06,136.26 70.09,136.28 70.1,136.28
DGND on L05_SIG02 (solid shape): 24.34,136.7 24.36,136.69 24.38,136.66 24.39,136.65 24.38,136.62 20.26,132.5 20.25,132.48 20.25,132.46 20.25,131.62 20.24,131.59 20.22,131.57 20.12,131.53 20.09,131.53 20.08,131.54 19.68,131.76 19.24,131.79 19.22,131.79 19.19,131.8 19.14,131.9 19.14,131.93 19.15,131.96 20.28,133.09 20.29,133.11 20.3,133.13 20.3,133.71 20.3,133.73 20.31,133.74 23.25,136.68 23.27,136.69 23.28,136.7
DGND on L05_SIG02 (solid shape): 10.17,116.49 10.19,116.5 10.21,116.51 10.3,116.5 10.32,116.49 10.33,116.48 10.38,116.42 10.44,116.38 10.45,116.37 10.47,116.35 10.47,116.23 10.45,116.2 10.44,116.2 10.27,115.88 10.49,115.59 10.5,115.59 10.52,115.57 10.54,115.47 10.54,115.45 10.52,115.43 9.13,114.03 9.1,114.02 9.08,114.02 9.06,114.03 9.04,114.05 9.04,115.35 9.05,115.36 9.06,115.38
DGND on L05_SIG02 (solid shape): 25.16,50.7 25.19,50.7 25.21,50.69 25.97,49.92 25.99,49.91 26.01,49.9 27.21,49.9 27.23,49.9 27.25,49.89 27.96,49.18 27.97,49.16 27.97,49.14 27.97,47.7 27.98,47.68 27.99,47.66 29.8,45.85 29.81,45.83 29.82,45.81 29.82,41 29.81,40.97 29.78,40.95 29.77,40.95 29.74,40.95 28.89,41.8 28.88,41.82 28.88,41.84 28.88,46.44 28.87,46.46 28.86,46.47 24.94,50.4 24.93,50.41 24.92,50.44 24.93,50.52 24.94,50.54 24.95,50.55 25,50.6 25.04,50.66 25.05,50.67 25.07,50.69
DGND on L05_SIG02 (solid shape): 66.78,129.39 66.9,129.37 67.02,129.39 67.03,129.39 67.06,129.39 67.13,129.33 67.15,129.31 67.15,129.29 67.15,127.55 67.16,127.53 67.17,127.52 67.34,127.35 67.35,127.33 67.35,127.31 67.35,119.7 67.34,119.67 67.32,119.65 67.31,119.64 67.28,119.65 66.95,119.98 66.94,119.99 66.94,120.01 66.94,125.76 66.93,125.77 66.92,125.79 66.73,125.98 66.72,126 66.72,126.01 66.72,128.68 66.71,128.7 66.7,128.72 66.66,128.76 66.65,128.78 66.64,128.8 66.64,129.3 66.65,129.32 66.67,129.34 66.75,129.39 66.77,129.4
DGND on L05_SIG02 (solid shape): 16.54,117.49 16.56,117.48 16.57,117.47 16.85,117.2 16.86,117.19 16.88,117.19 23.99,117.19 24.01,117.18 24.03,117.17 24.08,117.1 24.09,117.08 24.09,117.07 24.09,116.98 24.11,116.89 24.11,116.88 24.11,116.86 24.06,116.78 24.04,116.76 24.01,116.75 17.98,116.75 17.96,116.75 17.94,116.74 17.63,116.42 17.61,116.41 17.59,116.41 16.23,116.41 16.19,116.42 16.17,116.46 16.17,117.13 16.17,117.15 16.16,117.17 15.97,117.35 15.95,117.38 15.91,117.4 15.9,117.42 15.9,117.44 15.91,117.47 15.95,117.49
DGND on L05_SIG02 (solid shape): 64.03,18.56 64.06,18.55 64.08,18.54 64.29,18.33 64.31,18.3 64.3,18.27 64.3,18.26 64.27,18.24 63.37,18.24 63.35,18.23 63.33,18.22 62.56,17.46 62.55,17.44 62.55,17.42 62.55,16.9 62.55,16.88 62.53,16.87 62.18,16.51 62.16,16.5 62.14,16.5 61.56,16.5 61.53,16.51 61.51,16.53 61.51,16.54 61.51,16.57 63.37,18.44 63.39,18.45 63.44,18.44 63.7,18.38 63.92,18.53 63.93,18.54 63.94,18.55
DGND on L05_SIG02 (solid shape): 18.39,56.95 18.41,56.94 18.43,56.93 19.39,55.97 19.41,55.94 19.4,55.91 19.4,55.9 19.37,55.88 18.64,55.88 18.62,55.88 18.6,55.87 18.25,55.52 18.23,55.5 18.21,55.5 17.45,55.5 17.43,55.5 17.42,55.52 16.52,56.41 16.51,56.44 16.51,56.47 16.52,56.48 16.54,56.5 17.71,56.5 17.74,56.49 18.11,56.47 18.26,56.82 18.25,56.84 18.26,56.86 18.32,56.93 18.33,56.94 18.36,56.95
DGND on L05_SIG02 (solid shape): 36.39,152.4 36.41,152.4 36.42,152.39 36.69,152.12 36.7,152.1 36.7,152.07 36.69,152.05 36.67,152.04 29.3,152.04 29.28,152.03 29.27,152.02 27.32,150.08 27.31,150.07 27.29,150.06 11.98,150.06 11.96,150.06 11.94,150.05 10.27,148.38 10.26,148.36 10.26,148.34 10.26,147.09 10.25,147.06 10.22,147.04 10.21,147.03 10.18,147.04 8.68,148.54 8.66,148.56 8.64,148.56 5.82,148.56 5.79,148.57 5.77,148.59 5.77,148.61 5.77,148.64 8.02,150.88 8.04,150.89 8.06,150.9 26.76,150.9 26.78,150.9 26.8,150.91 28.27,152.39 28.29,152.4 28.31,152.4
DGND on L05_SIG02 (solid shape): 65.11,130.35 65.14,130.36 65.17,130.34 65.35,130.16 65.36,130.14 65.37,130.12 65.37,126.35 65.36,126.32 65.34,126.3 65.32,126.3 65.29,126.3 64.81,126.79 64.79,126.8 64.77,126.8 63.59,126.8 63.56,126.81 63.54,126.84 63.52,126.96 63.53,126.99 63.55,127 64.87,128.35 65,130.24 64.99,130.26 65.01,130.29
DGND on L05_SIG02 (solid shape): 24,119.25 24.02,119.24 24.04,119.23 24.1,119.15 24.1,119.13 24.1,119.11 24.09,118.98 24.13,118.85 24.14,118.84 24.14,118.81 24.09,118.72 24.07,118.71 24.04,118.7 16.74,118.7 16.72,118.69 16.7,118.68 16.53,118.51 16.52,118.5 16.5,118.5 15.08,118.5 15.05,118.5 15.04,118.52 14.98,118.6 14.98,118.63 14.99,118.64 15.01,118.81 14.95,118.96 14.94,118.98 14.94,119 14.99,119.1 15.01,119.12 15.03,119.12 16.82,119.12 16.84,119.13 16.86,119.14 16.95,119.23 16.97,119.24 16.99,119.25
DGND on L05_SIG02 (solid shape): 17.64,63.96 17.66,63.94 17.67,63.92 17.67,60.93 17.67,60.91 17.68,60.89 19.15,59.42 19.17,59.4 19.16,59.37 19.16,59.35 19.13,59.34 18.84,59.34 18.82,59.34 18.8,59.35 16.76,61.39 16.74,61.4 16.72,61.41 16.35,61.41 16.33,61.41 16.31,61.42 16.05,61.69 16.04,61.7 16.03,61.72 16.03,63.91 16.04,63.94 16.06,63.96 16.16,64 16.19,64 16.2,63.99 16.85,63.75 17.5,63.99 17.51,64 17.54,64.01
DGND on L05_SIG02 (solid shape): 58.21,145.61 58.23,145.6 58.25,145.59 59.5,144.34 59.52,144.33 59.54,144.32 60.96,144.32 60.98,144.32 61,144.31 68.61,136.69 68.62,136.68 68.63,136.66 68.63,136.59 68.62,136.56 68.6,136.54 68.58,136.54 68.55,136.54 61.08,144.02 61.06,144.03 61.04,144.03 59.2,144.03 59.18,144.03 59.17,144.05 58.38,144.83 58.37,144.84 58.35,144.85 55.29,144.85 55.26,144.85 55.25,144.87 55.2,144.97 55.2,145 55.21,145.01 55.29,145.23 55.21,145.44 55.2,145.45 55.19,145.48 55.24,145.58 55.26,145.6 55.28,145.61
DGND on L05_SIG02 (solid shape): 62.15,42.27 62.17,42.27 62.18,42.26 62.51,41.93 62.53,41.92 62.54,41.91 62.7,41.91 62.72,41.91 62.74,41.88 62.78,41.78 62.77,41.75 62.76,41.74 62.69,41.65 62.65,41.54 62.64,41.51 62.06,40.93 62.05,40.91 62.04,40.89 62.04,40.57 62.04,40.55 62.03,40.53 61.8,40.3 61.79,40.29 61.77,40.29 61.41,40.29 61.38,40.29 61.37,40.31 61.31,40.37 61.3,40.4 61.29,40.53 61.23,40.67 61.23,41.94 61.23,41.96 61.24,41.97 61.53,42.26 61.54,42.27 61.56,42.27
DGND on L05_SIG02 (solid shape): 28.45,66.39 29.27,65.57 29.29,65.56 29.31,65.56 30.32,65.56 30.34,65.55 30.36,65.54 30.64,65.26 30.66,65.24 30.68,65.24 31.05,65.24 31.07,65.23 31.09,65.22 31.15,65.14 31.15,65.12 31.15,65.1 31.1,64.55 31.36,64.07 31.37,64.06 31.37,64.03 31.33,63.93 31.31,63.9 31.28,63.9 29.19,63.9 29.17,63.9 29.15,63.91 28.67,64.39 28.66,64.41 28.65,64.43 28.65,65.66 28.65,65.67 28.64,65.69 28.39,65.94 28.38,65.96 28.37,65.98 28.37,66.35 28.38,66.37 28.41,66.39 28.42,66.4
DGND on L05_SIG02 (solid shape): 34.26,36.54 34.28,36.53 34.3,36.52 34.35,36.44 34.36,36.41 34.35,36.4 34.37,36.11 34.61,35.95 34.64,35.95 36.09,34.5 36.1,34.48 36.12,34.48 36.72,34.48 36.74,34.47 36.76,34.46 36.81,34.37 36.81,34.35 36.81,34.34 36.78,34.22 36.79,34.1 36.8,34.09 36.79,34.07 36.74,33.99 36.72,33.98 36.7,33.97 36.08,33.97 36.06,33.98 36.04,33.99 33.73,36.31 33.71,36.36 33.69,36.41 33.7,36.44 33.75,36.52 33.77,36.53 33.79,36.54
DGND on L05_SIG02 (solid shape): 49.64,34.35 49.66,34.35 49.68,34.33 50.21,33.81 50.23,33.79 50.24,33.79 53.63,33.79 53.65,33.79 53.66,33.78 55.05,32.39 55.07,32.38 55.09,32.37 55.4,32.37 55.42,32.37 55.43,32.36 55.87,31.92 55.88,31.9 55.88,31.87 55.87,31.85 55.84,31.84 55.1,31.84 55.09,31.84 55.07,31.85 54.6,32.32 54.59,32.33 54.57,32.33 54.42,32.33 54.4,32.34 54.39,32.35 53.92,32.82 53.9,32.83 53.89,32.83 53.12,32.83 53.1,32.83 53.08,32.85 52.59,33.34 52.57,33.35 52.55,33.36 49.75,33.36 49.73,33.36 49.71,33.37 48.82,34.26 48.8,34.29 48.81,34.32 48.81,34.33 48.84,34.35
DGND on L05_SIG02 (solid shape): 17.65,114.72 17.67,114.72 17.69,114.71 17.98,114.42 17.99,114.4 18,114.38 18,114.03 18,113.99 18.01,113.93 18.01,113.91 17.95,113.83 17.94,113.82 17.91,113.81 16.55,113.81 16.53,113.81 16.51,113.8 15.99,113.28 15.98,113.27 15.96,113.26 15.41,113.26 15.38,113.27 15.36,113.3 15.36,113.31 15.36,113.34 16.27,114.25 16.29,114.26 16.31,114.26 16.84,114.26 16.87,114.25 17.25,114.24 17.39,114.6 17.38,114.61 17.39,114.63 17.45,114.7 17.46,114.72 17.49,114.72
DGND on L05_SIG02 (solid shape): 24.12,41.99 24.88,41.23 24.89,41.21 24.9,41.19 24.9,40.75 24.9,40.73 24.91,40.71 25.73,39.9 25.74,39.88 25.74,39.85 25.71,39.76 25.7,39.74 25.68,39.73 25.49,39.57 25.47,39.32 25.47,39.31 25.47,39.29 25.41,39.21 25.39,39.2 25.37,39.19 24.9,39.19 24.88,39.19 24.87,39.18 23.95,38.26 23.93,38.25 23.91,38.24 23.64,38.24 23.62,38.25 23.6,38.26 23.54,38.34 23.54,38.36 23.56,38.43 24.03,38.9 24.04,38.92 24.05,38.94 24.05,41.94 24.05,41.97 24.08,41.99 24.09,42
DGND on L05_SIG02 (solid shape): 30.65,95.34 30.73,95.33 30.79,95.27 30.8,95.25 30.81,95.23 30.81,94.5 30.8,94.48 30.79,94.46 30.44,94.11 30.43,94.1 30.43,94.08 30.43,93.97 30.41,93.93 30.38,93.91 30.36,93.91 30.34,93.93 30.33,93.94 30.1,94.26 29.79,94.5 29.76,94.56 29.82,94.6 29.85,94.59 30.05,94.59 30.16,94.61 30.24,94.67 30.4,94.83 30.46,94.92 30.48,95.02 30.48,95.25 30.48,95.27 30.5,95.29 30.57,95.34 30.59,95.35
DGND on L05_SIG02 (solid shape): 16.45,91.3 16.53,91.24 16.55,91.22 16.55,91.2 16.55,91.15 16.56,91.13 16.57,91.12 16.64,91.04 16.65,91.03 16.66,91.01 16.66,88.78 16.65,88.76 16.64,88.74 16.34,88.44 16.33,88.42 16.33,88.4 16.33,85.45 16.32,85.43 16.31,85.41 15.89,85 15.88,84.98 15.86,84.92 15.77,84.91 15.69,84.92 15.63,84.98 15.61,84.99 15.61,85.01 15.61,87.96 15.61,87.98 15.63,87.99 16.13,88.5 16.14,88.51 16.14,88.53 16.14,91.16 16.15,91.18 16.16,91.2 16.22,91.26 16.33,91.27 16.41,91.29 16.42,91.3
DGND on L05_SIG02 (solid shape): 38.97,38.37 39,38.37 39.03,38.36 39.1,38.28 39.11,38.26 39.25,38.04 39.5,37.98 39.52,37.98 39.54,37.98 39.61,37.92 39.62,37.9 39.63,37.88 39.63,37.38 39.62,37.36 39.61,37.34 39.33,37.06 39.32,37.05 39.3,37.05 32.21,37.05 32.18,37.06 32.17,37.08 32.16,37.09 32.17,37.12 33.24,38.2 33.26,38.21 33.28,38.21 38.18,38.21 38.21,38.2 38.22,38.18 38.58,37.98 38.85,38.29 38.85,38.3 38.87,38.33
DGND on L05_SIG02 (solid shape): 61.98,97.69 62.01,97.69 62.04,97.68 62.19,97.53 62.2,97.51 62.21,97.49 62.21,90.76 62.21,90.74 62.22,90.72 62.24,90.7 62.26,90.67 62.24,90.63 62.22,90.62 62.08,90.56 61.99,90.45 61.98,90.44 61.96,90.42 61.84,90.42 61.81,90.44 61.81,90.45 61.66,90.59 61.46,90.62 61.45,90.62 61.43,90.62 61.36,90.68 61.35,90.7 61.34,90.72 61.34,91.56 61.35,91.58 61.36,91.6 61.81,92.05 61.82,92.07 61.83,92.09 61.83,97.47 61.83,97.49 61.84,97.51 61.94,97.61 61.95,97.62 61.95,97.66 61.97,97.68
DGND on L05_SIG02 (solid shape): 63.11,125.56 63.14,125.55 63.16,125.52 63.2,125.42 63.19,125.39 63.18,125.38 63.09,125.03 63.37,124.81 63.4,124.8 63.45,124.74 63.46,124.72 63.47,124.7 63.47,124.44 63.46,124.41 63.44,124.39 63.42,124.39 63.39,124.39 62.93,124.86 62.91,124.87 62.89,124.87 62.45,124.87 62.43,124.88 62.41,124.89 62.29,125.01 62.28,125.03 62.27,125.05 62.27,125.36 62.27,125.38 62.24,125.42 62.23,125.45 62.24,125.49 62.3,125.52 62.38,125.56
DGND on L05_SIG02 (solid shape): 66.54,44.48 66.57,44.49 66.59,44.49 66.61,44.48 66.63,44.45 66.63,40.57 66.62,40.55 66.61,40.53 66.53,40.48 66.5,40.47 66.49,40.48 66.39,40.49 66.29,40.48 66.28,40.47 66.26,40.48 66.18,40.53 66.17,40.55 66.16,40.57 66.16,42.05 66.16,42.07 66.15,42.09 65.83,42.4 65.82,42.42 65.81,42.44 65.81,43.23 65.82,43.26 65.84,43.27 65.91,43.33 65.94,43.33 65.95,43.33 66.37,43.52 66.2,43.94 66.19,43.95 66.17,43.97 66.16,44.06 66.16,44.08 66.17,44.11
DGND on L05_SIG02 (solid shape): 51.21,105.58 51.24,105.57 51.26,105.55 51.27,105.53 51.26,105.5 51.21,105.45 51.19,105.43 51.19,105.41 51.19,105.01 51.18,104.98 51.16,104.96 51.14,104.95 51.12,104.96 51.05,105.02 51.04,105.03 51.02,105.04 50.48,105.04 50.46,105.03 50.44,105.02 50.33,104.91 50.31,104.9 50.29,104.9 49.51,104.9 49.49,104.9 49.47,104.91 49.45,104.94 49.43,104.97 49.45,105.01 49.46,105.02 49.58,105.15 49.62,105.33 49.62,105.34 49.64,105.37 49.74,105.42 49.77,105.42 49.8,105.41 49.83,105.38 49.85,105.37 50.75,105.37 50.77,105.38 50.79,105.39 50.96,105.56 50.98,105.58 51,105.58
DGND on L05_SIG02 (solid shape): 10.23,127.57 10.25,127.55 10.26,127.52 10.26,127.42 10.27,127.41 10.28,127.39 12.17,125.5 12.19,125.48 12.21,125.48 14.22,125.48 14.24,125.48 14.26,125.47 14.33,125.39 14.34,125.38 14.34,125.36 14.34,125.28 14.29,125.2 14.25,125.13 14.22,125.12 14.18,125.14 11.81,125.14 11.79,125.13 11.77,125.12 10.61,123.96 10.58,123.95 10.55,123.95 10.54,123.95 10.52,123.98 10.52,125.68 10.51,125.7 10.5,125.71 9.24,126.98 9.22,127 9.22,127.03 9.26,127.13 9.29,127.15 9.3,127.15 9.74,127.28 10.08,127.58 10.09,127.6 10.12,127.61
DGND on L05_SIG02 (solid shape): 33.64,53.39 33.66,53.39 33.68,53.38 33.98,53.08 33.99,53.05 34.24,52.78 34.59,52.91 34.6,52.92 34.61,52.93 34.7,52.94 34.73,52.94 34.74,52.92 36.25,51.42 36.26,51.41 36.26,51.39 36.26,49.86 36.26,49.84 36.28,49.83 38.31,47.79 38.32,47.78 38.32,47.75 38.32,47.67 38.3,47.64 38.23,47.56 38.19,47.46 38.18,47.45 38.16,47.43 38.07,47.4 38.04,47.4 38.02,47.41 32.49,52.93 32.48,52.94 32.46,52.95 29.29,52.95 29.27,52.95 29.25,52.96 28.91,53.31 28.89,53.33 28.9,53.36 28.9,53.38 28.93,53.39
DGND on L05_SIG02 (solid shape): 66.78,119.42 67.11,119.1 67.12,119.08 67.12,119.06 67.12,114.83 67.12,114.81 67.11,114.79 66.76,114.44 66.75,114.43 66.74,114.41 66.74,113.59 66.75,113.57 66.77,113.55 66.85,113.51 66.88,113.48 66.88,113.44 66.85,113.42 66.65,113.19 66.72,112.9 66.73,112.87 66.73,112.79 66.7,112.73 66.67,112.69 66.65,112.67 66.56,112.66 66.53,112.66 66.51,112.67 66.45,112.73 66.44,112.75 66.44,112.77 66.44,115.46 66.44,115.47 66.45,115.49 66.69,115.73 66.7,115.75 66.71,115.77 66.71,119.38 66.72,119.41 66.74,119.42 66.75,119.43
DGND on L05_SIG02 (solid shape): 15.54,82.85 15.56,82.83 15.57,82.8 15.57,82.61 15.58,82.59 15.59,82.58 15.74,82.42 15.75,82.4 15.76,82.38 15.76,77.05 15.76,77.03 15.77,77.01 15.96,76.82 15.97,76.8 15.97,76.75 15.95,76.73 15.93,76.71 15.9,76.71 15.88,76.71 15.7,76.74 15.54,76.68 15.51,76.67 15.18,76.67 15.16,76.66 15.14,76.65 14.16,75.67 14.14,75.66 14.11,75.66 14.09,75.66 14.07,75.69 14.07,75.81 14.08,75.83 14.09,75.84 15.14,76.89 15.15,76.91 15.15,76.93 15.15,82.74 15.16,82.76 15.17,82.77 15.22,82.83 15.25,82.84 15.34,82.85 15.41,82.89 15.43,82.9 15.45,82.9
DGND on L05_SIG02 (solid shape): 45.45,95.79 45.47,95.79 45.49,95.78 45.54,95.71 45.55,95.68 45.66,95.42 45.95,95.34 45.99,95.33 46.01,95.29 46.01,95.24 45.99,95.2 45.84,95.19 45.74,95.17 45.73,95.16 45.7,95.17 45.35,95.51 45.34,95.52 45.32,95.53 44.8,95.53 44.78,95.52 44.77,95.51 44.58,95.32 44.56,95.31 44.52,95.31 44.5,95.32 44.32,95.51 44.3,95.52 44.28,95.53 44.03,95.53 44.01,95.53 43.99,95.54 43.81,95.73 43.8,95.73 43.82,95.76 43.83,95.78 43.86,95.79
DGND on L05_SIG02 (solid shape): 42.31,108.61 42.35,108.6 42.34,108.49 42.04,108.18 42.03,108.17 42.03,108.15 42.03,108.09 42.02,108.07 42.01,108.06 41.94,108 41.91,107.99 41.65,107.9 41.55,107.63 41.55,107.6 41.49,107.54 41.47,107.52 41.45,107.52 40.71,107.52 40.69,107.52 40.67,107.54 40.61,107.6 40.61,107.66 40.61,107.73 40.67,107.79 40.69,107.81 40.71,107.81 41.32,107.81 41.35,107.81 41.37,107.83 41.72,108.18 41.73,108.2 41.73,108.21 41.73,108.5 41.74,108.52 41.75,108.54 41.83,108.61
DGND on L05_SIG02 (solid shape): 7.26,116.61 7.28,116.62 7.31,116.62 7.33,116.62 7.34,116.59 7.34,114.31 7.34,114.29 7.33,114.28 7.2,114.15 7.19,114.14 7.17,114.14 6.7,114.14 6.68,114.13 6.65,114.11 6.61,114.11 6.59,114.13 6.58,114.16 6.46,114.42 6.17,114.48 6.16,114.48 6.14,114.49 6.07,114.54 6.05,114.56 6.05,114.58 6.05,114.84 6.05,114.86 6.07,114.88 6.13,114.93 6.16,114.94 6.17,114.94 6.54,115.15 6.38,115.55 6.37,115.56 6.36,115.58 6.35,115.67 6.35,115.69 6.36,115.71
