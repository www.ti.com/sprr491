# Allegro board PROC135A_BRD.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WL_LT_EN: length 9.6
  TOP w0.14: U1.8 44.78,151.53 44.94,151.69 R6.1 R7.2 46.15,150.78 46.65,150.28 46.65,147.18 47.36,146.47 48.2,146.47 48.51,146.78 U2.9
WLAN_ALERT_1V8: length 34.2
  TOP w0.14: v1(11.78,148.74) 11.88,148.84 R8.2 ; U1.5 v1(42.9,148.39)
  L05_SIG02 w0.102: v1(42.9,148.39) 42.6,148.7 42.08,148.7 40.98,149.8 38.9,149.8 37.83,150.87 28.89,150.87 26.76,148.74 v1(11.78,148.74)
WLAN_ALERTN: length 144.1
  TOP w0.14: U1.10 42.9,153.16 43.28,153.54 R2.1 v1(44.19,153)
  L03_SIG01 w0.102: v1(60.96,50.59) 63.41,50.59 66.06,53.24 67.99,53.24 v1(72.27,57.52)
  L05_SIG02 w0.102: v1(72.27,57.52) 71.53,58.25 71.53,63.77 70.88,64.42 70.88,79.19 70.33,79.74 70.33,87.05 70.88,87.6 70.88,101.32 73.07,103.51 73.07,110.9 73.35,111.18 73.35,123.47 72.84,123.98 72.84,126.88 73.12,127.16 73.12,130.1 73.5,130.48 73.5,139.79 72.65,140.64 69.74,140.64 67.56,142.83 66.36,142.83 62.18,147 59.67,147 58.98,147.69 48.64,147.69 46.84,149.49 46.84,150.34 v1(44.19,153)
  BOTTOM w0.14: v1(60.96,50.59) 56.2,45.84 U92.16
WLAN_EN: length 47.9
  TOP w0.132: U18.F22 v1(34.68,112.46)
  TOP w0.14: U1.4 42.4,148.22 42.64,147.99 R11.1 R12.2 45.03,147.99 v1(45.19,148.15)
  BOTTOM w0.14: v1(34.68,112.46) 34.68,113.46 35.12,113.89 35.12,115.44 33.38,117.18 33.38,123.81 33.63,124.07 33.63,126.94 33.38,127.19 33.38,132.9 37.59,137.12 37.59,140.3 39.68,142.38 39.68,145.81 40.09,146.22 41.7,146.22 43.15,147.66 44.71,147.66 v1(45.19,148.15)
WLAN_EN_3V3: length 8.1
  TOP w0.14: U1.11 v1(42.4,153.33) ; R10.2 41.67,147.43 v1(41.61,147.36)
  L03_SIG01 w0.102: v1(41.61,147.36) 41.53,147.36 41.34,147.55 41.34,148.87 41.04,149.18 41.04,151.74 42.4,153.11 v1(42.4,153.33)
WLAN_IRQ: length 61.1
  TOP w0.132: U18.E21 v1(33.88,111.66)
  TOP w0.14: v1(4.75,140.04) 4.25,139.54 J2.21
  L05_SIG02 w0.102: v1(4.75,140.04) 5.36,140.65 8.56,140.65 9.5,139.71 9.5,136.08 10.52,135.07 10.52,127.51 12.29,125.73 14.35,125.73 14.62,125.46 15.53,125.46 16.46,124.52 16.86,124.52 v1(16.91,124.47)
  L10_SIG03 w0.102: v1(16.91,124.47) 17.11,124.27 17.11,122.37 15.78,121.03 15.78,113.54 19.04,110.28 24.57,110.28 24.88,110.58 25.63,110.58 25.99,110.94 28.37,110.94 29.5,112.06 33.48,112.06 v1(33.88,111.66)
  BOTTOM w0.14: R262.1 v1(4.75,140.04)
WLAN_SDIO_RST: length 55.7
  TOP w0.14: J2.23 v1(3.84,140.04) ; v1(40.09,147.32) 40.93,147.32 41.13,147.52 R9.1 41.13,148.21 41.4,148.48 U1.2
  L05_SIG02 w0.102: v1(40.09,147.32) 39.57,147.32 36.82,150.07 29.48,150.07 23.68,144.26 15.17,144.26 13.59,142.68 11.18,142.68 10.19,143.67 10.19,146.67 8.56,148.31 5.6,148.31 3.84,146.54 v1(3.84,140.04)
XDS110_DIR: length 3.1
  BOTTOM w0.14: U111.4 65.73,20.93 65.56,21.11 65.56,21.71 ; 65.56,21.71 65.71,21.86 66.2,21.86 66.34,21.72 U111.5 ; 65.56,21.71 65.41,21.85 65.41,22.05 R517.2
XDS110_EMU0: length 21.2
  TOP w0.14: U47.42 70.78,13.43 71.14,13.07 R234.2 71.57,12.55 71.95,12.16 v1(72.49,12.16)
  L05_SIG02 w0.102: v1(64.04,17.51) 64.04,13.25 67.43,9.85 70.18,9.85 v1(72.49,12.16)
  BOTTOM w0.14: v1(64.04,17.51) 63.51,17.51 62.81,18.22 U112.7
XDS110_EMU1: length 15.3
  TOP w0.14: v1(71.1,14.48) 71.42,14.48 71.57,14.34 R233.2 U47.43
  BOTTOM w0.14: v1(71.1,14.48) 68.72,14.48 68.26,14.94 67.32,14.94 66.72,14.33 65.87,14.33 65.52,14.69 65.52,17.56 64.96,18.11 63.59,18.11 63.16,18.55 U112.6
XDS110_TCK: length 11.7
  TOP w0.14: U47.35 68.61,10.63 v1(68.28,10.3)
  L05_SIG02 w0.102: v1(67.34,18.15) 67.67,17.82 67.67,15.76 67.26,15.36 67.26,10.67 67.63,10.3 v1(68.28,10.3)
  BOTTOM w0.14: U111.14 67.14,18.34 v1(67.34,18.15)
XDS110_TDI: length 9.9
  TOP w0.14: v1(66.47,18.13) 66.47,16.03 67.12,15.38 67.12,12.76 68.11,11.77 68.81,11.77 68.86,11.83 U47.38
  BOTTOM w0.14: U111.15 66.74,18.39 v1(66.47,18.13)
XDS110_TDO: length 18.4
  TOP w0.14: v1(60.52,21.27) 61.78,20 61.97,20 62.88,19.09 62.88,17.97 63.93,16.92 63.93,14.57 64.26,14.24 64.26,12.69 65.41,11.55 67.81,11.55 67.93,11.43 U47.37
  BOTTOM w0.14: U109.7 59.92,20.67 v1(60.52,21.27)
XDS110_TMS: length 10.9
  TOP w0.14: U47.36 v1(67.66,11.03)
  L05_SIG02 w0.102: v1(67.66,11.03) 67.66,13.6 68.07,14.01 v1(68.07,18.55)
  BOTTOM w0.14: U111.13 67.54,18.7 67.69,18.55 v1(68.07,18.55)
XDS110_TRST#: length 9.2
  TOP w0.132: v1(68.69,19.01) 68.69,18.48 67.98,17.77 67.98,13.65 69,12.63 U47.40
  BOTTOM w0.14: U111.12 67.97,19.73 v1(68.69,19.01)
XDS_GPIO1: length 1.8
  TOP w0.14: U44.2 64.6,28.52 v1(64.49,28.63)
  BOTTOM w0.14: R484.2 v1(64.49,28.63)
XDS_GPIO2: length 2.4
  BOTTOM w0.14: R481.2 59.35,27.99 U102.7
XDS_GPIO3: length 1.8
  TOP w0.14: U44.4 v1(65.4,28.63)
  BOTTOM w0.14: R483.2 v1(65.4,28.63)
XDS_GPIO4: length 1.9
  TOP w0.14: v1(66.39,28.63) 66.2,28.44 U44.6
  BOTTOM w0.14: v1(66.39,28.63) 66.52,28.51 R482.2
XDS_PORZN: length 9.8
  TOP w0.14: v1(66.52,34.39) 66.6,34.3 U44.8
  L05_SIG02 w0.102: v1(66.52,34.39) 63.96,31.83 60.95,31.83 v1(60.09,32.69)
  BOTTOM w0.14: R472.2 v1(60.09,32.69)
XDS_POWERDOWN: length 2.5
  TOP w0.14: R194.2 64.8,35.26 65,35.05 U44.12
XDS_RSTN: length 5.6
  TOP w0.14: TP78.1 66.37,25.35 U47.70 66.37,22.85 66.64,22.58 v1(66.64,22.55)
  BOTTOM w0.14: v1(66.64,22.55) 66.64,22.97 R506.1 65.51,23.61 65.13,23.23 R511.1
XDS_SHIELD:
  vias: v1(77.57,12.08) v1(78.59,11.52) v1(78.59,10.61) v1(79.02,22.16) v1(80.8,22.16) v1(81.71,22.16) v1(82.07,18.25) v1(82.07,16.73) v1(82.07,15.2) v1(83.59,18.25) v1(83.59,16.73) v1(83.59,15.2)
XDS_USB_DM: length 29.7
  TOP w0.102: J18.2 78.63,16.1 78.41,16.32 78.01,16.32 v1(77.73,16.05) ; U47.93 57.12,23.68 57.12,22.87 57.07,22.82 57.07,22.45 v1(57.35,22.18)
  L05_SIG02 w0.102: v1(57.35,22.18) 56.99,22.53 56.99,22.76 57.74,23.51 67.9,23.51 71.22,20.2 71.55,20.2 74.94,16.8 75.72,16.8 76.09,16.42 77.63,16.42 77.73,16.32 v1(77.73,16.05)
  BOTTOM w0.102: v1(77.73,16.05) 77.46,16.32 77.25,16.32 77.1,16.18 U115.5
XDS_USB_DP: length 29.7
  TOP w0.102: v1(56.59,22.18) 56.86,22.45 56.86,22.82 56.81,22.87 56.81,23.68 U47.94 ; v1(77.73,16.81) 78.01,16.53 78.41,16.53 78.63,16.75 J18.3
  L05_SIG02 w0.102: v1(56.59,22.18) 56.79,22.38 56.79,22.85 57.65,23.71 67.99,23.71 71.3,20.4 71.63,20.4 75.03,17 75.8,17 76.18,16.63 77.55,16.63 v1(77.73,16.81)
  BOTTOM w0.102: U115.4 77.1,16.68 77.25,16.53 77.46,16.53 v1(77.73,16.81)
XDS_USB_ID: length 38.6
  TOP w0.14: R204.2 v1(56.68,27.17) ; J18.4 77.47,17.4 76.24,16.18 v1(75.66,16.18)
  L03_SIG01 w0.102: v1(75.66,16.18) 73.39,13.91 57.76,13.91 56.15,15.52 56.15,22.76 56.68,23.29 v1(56.68,27.17)
  BOTTOM w0.14: U115.2 v1(75.66,16.18)
XDS_USB_VBUS: length 4.6
  TOP w0.254: R237.1 49.21,7.26 49,7.46 v1(49,7.93) ; TP89.1 74.73,14.36 C155.1
  BOTTOM w0.254: U115.6 76.77,15.26 v1(76.6,15.09) ; R496.1 57.06,25.74 v1(57.44,26.12) ; R507.1 78.98,24.46 v1(78.72,24.73)
  vias: v1(74.16,21.63) v1(74.16,20.71) v1(74.94,20.71) v1(75.68,15.09) v1(77.51,15.09)
XDS_VREF: length 18.4
  TOP w0.203: U47.9 59.17,7.23 59.51,6.88 C165.2
  TOP w0.254: C165.2 v1(59.87,6.31) ; v1(70.58,7.39) R239.2 72.44,6.88 72.69,7.13 C161.1 U49.3
  L03_SIG01 w0.305: v1(70.58,7.39) 70.16,7.81 61.04,7.81 60.3,7.07 60.3,6.74 v1(59.87,6.31)
XDS_WARMRESETN: length 1.5
  TOP w0.14: U44.10 65.8,34.27 65.91,34.37 R198.2
N15951749: length 7.3
  BOTTOM w0.254: C177.1 23.63,138.25 24.28,137.6 24.28,135.79 24.06,135.56 U56.1 ; C177.1 R264.2 R272.2 ; C177.1 U56.4
N15952254: length 1.5
  BOTTOM w0.14: R280.1 20.46,136.77 20.65,136.96 U56.3
N16839912: length 2.4
  BOTTOM w0.14: U82.D3 3.9,73.76 C385.1 4.01,74.42 4.15,74.56 R375.1
N16839940: length 2.5
  BOTTOM w0.14: U83.D3 41.15,68.38 C392.1 41.15,70.14 41.28,70.27 R378.1
N16839975: length 2.5
  BOTTOM w0.14: U85.D3 31.86,68.38 C394.1 31.86,70.17 32.01,70.31 R382.1
N16856152: length 5.2
  TOP w0.14: Y5.2 12.63,15.56 14,16.93 C149.1 15.56,16.93 15.84,17.21 U48.3
N16856224: length 5.2
  TOP w0.14: U48.2 15.84,17.71 15.56,18 C148.1 14.01,18 12.64,19.36 Y5.1
N16857368: length 1.6
  BOTTOM w0.14: C504.2 13.06,10.09 U121.2
N16878333: length 1.2
  BOTTOM w0.14: U119.5 19.91,14.07 19.47,14.51 R560.2
N16878339: length 2.4
  BOTTOM w0.14: U119.4 19.23,13.26 19.08,13.41 19.08,14.37 18.59,14.86 R561.1
N16878497: length 1.9
  TOP w0.14: v1(57.48,79.26) 57.23,79.01 U28.H5
  BOTTOM w0.14: R368.1 v1(57.48,79.26) 57.42,79.26 TP100.1
N16880083: length 2.6
  TOP w0.14: R106.2 5.06,90.53 4.86,90.74 v1(4.86,91.16) 5.17,91.47 U24.1
  BOTTOM w0.14: v1(4.86,91.16) 4.49,90.79 R353.1
N16893179: length 1.2
  BOTTOM w0.14: R520.2 31.66,21.47 31.22,21.03 U110.5
N16893185: length 2.4
  BOTTOM w0.14: U110.4 30.41,21.72 30.57,21.88 31.2,21.88 31.69,22.36 R516.1
N16894003: length 1.4
  BOTTOM w0.14: U118.5 24.84,16.64 24.74,16.75 24.56,16.75 24.14,17.17 R540.2
N16894009: length 2.5
  BOTTOM w0.14: R541.1 23.25,17.17 23.99,16.43 23.99,15.73 24.15,15.57 U118.4
N16906426: length 4.8
  TOP w0.14: R71.1 25.63,105.47 25.01,106.09 C33.2 24.05,106.09 23.83,106.3 22.55,106.3 22.24,106 22.24,105.8 Y1.1
N16906432: length 2.6
  TOP w0.14: Y1.3 23.65,104.19 23.8,104.04 C36.2 R74.1
N16927060: length 1.9
  TOP w0.14: U13.72 15.22,112.77 14.94,112.48 14.94,112.01 R57.2
N16927228: length 1.1
  TOP w0.14: U13.69 R54.1
N16927289: length 1.3
  TOP w0.14: U13.36 25.68,121.27 26.16,121.76 R48.2
N16929458: length 2.6
  TOP w0.14: TP62.1 v1(79.69,47.29)
  BOTTOM w0.14: v1(79.69,47.29) 79.19,47.79 U88.7
N16929460: length 1.5
  TOP w0.14: TP61.1 v1(78.77,47.29)
  BOTTOM w0.14: U88.8 v1(78.77,47.29)
N16929474: length 1.8
  BOTTOM w0.14: U88.41 73.62,51.58 73.62,52.68 R404.2
N16929699: length 1.4
  TOP w0.14: C115.1 v1(78.77,49.29)
  BOTTOM w0.14: U88.4 v1(78.77,49.29)
N16929703: length 1.4
  TOP w0.14: C119.1 v1(78.77,48.29)
  BOTTOM w0.14: U88.6 v1(78.77,48.29)
N16929744: length 1.6
  TOP w0.14: TP67.1 v1(73.91,43.69)
  BOTTOM w0.14: U88.19 74.16,43.94 v1(73.91,43.69)
N16929747: length 1.6
  TOP w0.14: TP66.1 v1(72.91,43.69)
  BOTTOM w0.14: U88.22 72.66,43.94 v1(72.91,43.69)
N16929749: length 1.9
  BOTTOM w0.14: TP102.1 69.53,50.29 U88.35
N16929751: length 3.2
  BOTTOM w0.14: TP103.1 68.56,49.44 69.77,49.44 70.12,49.79 U88.34
N16931396: length 1.5
  BOTTOM w0.14: R270.2 6.44,138.1 6.11,137.76 U53.B2
N16931420: length 1.2
  BOTTOM w0.14: U53.C1 5.12,136.78 R281.1
N16943223: length 1.7
  TOP w0.14: U7.2 50.7,135.73 R33.1
N16947096: length 1.4
  TOP w0.14: R23.1 U6.1
N16960546: length 1.5
  TOP w0.14: U12.B2 v1(50.35,120.4)
  BOTTOM w0.14: R313.2 v1(50.35,120.4)
N16990175: length 2.7
  BOTTOM w0.14: R555.2 61.77,15.32 60.75,14.3 J23.27
N16990176: length 2.4
  BOTTOM w0.14: J23.30 59.25,14.64 59.51,14.9 R556.2
N16990179: length 4.7
  BOTTOM w0.14: R533.2 58.21,17.84 58.57,17.48 58.57,15.09 58.75,14.92 J23.31
N16990180: length 2.7
  BOTTOM w0.14: R557.2 58.25,14.61 J23.32
N16990246: length 4.4
  BOTTOM w0.14: J23.26 61.25,14.24 61.64,14.64 63.47,14.64 63.95,15.12 R554.2
N16990247: length 5.1
  BOTTOM w0.14: R532.2 60.4,17.84 61.08,17.16 61.08,15.33 60.25,14.5 J23.28
N16990252: length 5.3
  BOTTOM w0.14: J23.33 57.75,14.32 57.44,14.63 56.86,14.63 56.63,14.86 56.63,17.24 R536.2
N16994873: length 1.2
  BOTTOM w0.14: U107.4 47.11,24.21 47.18,24.28 R499.2
N16994875: length 1.1
  BOTTOM w0.102: R562.2 U117.4
N16995245: length 0.9
  BOTTOM w0.14: R519.2 C474.1
N16997746: length 5.6
  TOP w0.14: U47.59 70.89,20.23 71.07,20.05 71.07,19.35 71.42,19.01 73.8,19.01 74.33,19.53 R232.1
N17030208: length 1.6
  BOTTOM w0.14: U111.7 67.14,22.15 67.43,22.43 R515.2
N17031262: length 1.7
  TOP w0.254: LD6.2 R203.2
N17078351: length 1.5
  TOP w0.14: SW2.13 R209.1
N17078353: length 1.5
  TOP w0.14: SW2.14 R210.1
N17078355: length 1.5
  TOP w0.132: SW2.15 R211.1
N17078357: length 1.5
  TOP w0.102: 41.01,27.42 R212.1
  TOP w0.14: SW2.16 41.01,27.42
N17078758: length 1.5
  TOP w0.14: SW3.11 R215.1
N17078760: length 1.5
  TOP w0.14: SW3.12 R216.1
N17078762: length 1.5
  TOP w0.14: SW3.13 R217.1
N17078764: length 1.5
  TOP w0.14: SW3.14 R218.1
N17078766: length 1.5
  TOP w0.14: SW3.9 R213.1
N17078768: length 1.5
  TOP w0.14: SW3.10 R214.1
N17078770: length 1.5
  TOP w0.14: SW3.15 R219.1
N17078778: length 1.5
  TOP w0.14: SW3.16 R220.1
N17078974: length 2
  BOTTOM w0.14: R495.2 81.1,25.22 81.31,25.01 J16.2
N17084256: length 1.5
  TOP w0.132: SW2.9 R205.1
N17084257: length 1.5
  TOP w0.14: SW2.10 R206.1
N17084258: length 1.5
  TOP w0.14: SW2.11 R207.1
N17084259: length 1.5
  TOP w0.14: SW2.12 R208.1
N17110597: length 1.5
  TOP w0.14: v1(64.16,91.39) TP26.1
  BOTTOM w0.14: v1(64.16,91.39) U78.13
N17137240: length 1.6
  BOTTOM w0.14: J6.11 R330.2
N17153379: length 15.6
  TOP w0.14: R102.2 1.72,95.4 1.86,95.54 v1(2.4,95.54) ; v1(14.48,93.48) 14.64,93.64 R101.3
  L03_SIG01 w0.102: v1(14.48,93.48) 14.36,93.36 9.2,93.36 8.37,94.2 4.68,94.2 4.07,94.81 3.13,94.81 v1(2.4,95.54)
N17153381: length 15
  TOP w0.14: v1(3.29,95.56) 3,95.56 2.87,95.43 R103.2 ; v1(14.82,95.24) 14.99,95.24 15.09,95.34 R101.2
  L03_SIG01 w0.102: v1(14.82,95.24) 14.72,95.14 14.69,95.14 13.2,93.64 9.5,93.64 8.66,94.48 4.83,94.48 4.19,95.11 3.66,95.11 3.29,95.48 v1(3.29,95.56)
N17153383:
  vias: v1(25.33,86.7) v1(25.33,86.06)
N17153415: length 24.2
  L05_SIG02 w0.102: v1(26.88,79.36) 27.38,78.86 27.38,77.58 30.18,74.78 34.37,74.78 36.04,73.11 36.04,72.56 36.14,72.46 v1(36.51,72.46)
  BOTTOM w0.14: R356.1 26.3,87.7 26.68,87.32 26.68,82.07 27.23,81.52 27.23,79.72 v1(26.88,79.36) ; R380.2 v1(36.51,72.46)
N17153417: length 25.6
  L05_SIG02 w0.102: v1(26.88,78.27) 26.88,77.72 30.11,74.49 34.24,74.49 35.76,72.97 35.76,72.65 35.58,72.46 v1(35.24,72.46)
  BOTTOM w0.14: v1(26.88,78.27) 27.54,78.93 27.54,81.62 27.01,82.15 27.01,88.12 25.88,89.25 R356.4 ; R381.2 v1(35.24,72.46)
N17153507: length 11.3
  TOP w0.14: R94.1 10.91,96.47 10.67,96.71 v1(10.67,97.08) ; v1(11.18,105.17) 11.18,105.4 10.92,105.66 R66.2
  BOTTOM w0.14: v1(10.67,97.08) 10.01,97.73 10.01,101.21 9.71,101.51 9.71,103.7 v1(11.18,105.17)
N17153509: length 8.7
  TOP w0.14: R94.4 v1(10.68,98.02) ; R72.2 v1(11.2,104.39)
  BOTTOM w0.14: v1(10.68,98.02) 10.39,98.31 10.39,101.39 10.04,101.74 10.04,103.59 10.83,104.39 v1(11.2,104.39)
N17153511: length 3.3
  TOP w0.14: R72.1 9.04,104.39 8.89,104.53 C34.2 7.78,104.53 7.55,104.76 ; U17.D2 7.37,105.16 7.55,104.99 7.55,104.76 ; U17.D1 7.55,104.76
N17153515: length 2.5
  TOP w0.14: R66.1 8.99,105.66 8.84,105.51 C34.1 7.62,105.51 7.57,105.56 U17.D3
N17153617: length 11.5
  TOP w0.14: R120.1 1.79,85.52 1.42,85.15 1.42,78.98 3.67,76.73 v1(4.15,76.73)
  BOTTOM w0.14: R375.2 v1(4.15,76.73)
N17153619: length 12.9
  TOP w0.14: v1(2.39,76.85) 2.03,76.85 1.09,77.79 1.09,86.3 1.86,87.07 R120.4
  BOTTOM w0.14: v1(2.39,76.85) 2.74,76.85 2.88,76.71 R376.2
N17153623: length 5.6
  TOP w0.14: R132.1 v1(44.11,74.83)
  BOTTOM w0.14: v1(44.11,74.83) 43.09,74.83 41.28,73.02 R378.2
N17153625: length 8.8
  TOP w0.14: R132.4 v1(45.66,74.83)
  BOTTOM w0.14: R379.2 40.01,72.66 42.98,75.63 44.86,75.63 v1(45.66,74.83)
N17153667: length 8.4
  TOP w0.14: R131.3 v1(27.02,75.02)
  BOTTOM w0.14: v1(27.02,75.02) 27.55,75.55 29.62,75.55 31.57,73.6 31.57,72.16 R382.2
N17153669: length 5.8
  TOP w0.14: R131.2 v1(28.71,75.02)
  BOTTOM w0.14: R383.2 31.24,72.24 31.24,73.39 29.62,75.02 v1(28.71,75.02)
N17153681: length 2.6
  TOP w0.14: U25.D3 1.82,91.56 1.79,91.59 C69.1 1.79,93.1 1.72,93.17 R102.1
N17153685: length 3.5
  TOP w0.14: U25.D2 2.22,91.47 2.62,91.87 ; R103.1 2.87,93.2 2.77,93.1 C69.2 2.77,92.02 2.62,91.87 ; U25.D1 2.62,91.87
N17153701: length 3.3
  BOTTOM w0.14: U84.D1 35.55,68.96 ; 35.55,68.96 35.42,69.08 C393.2 35.42,70.01 35.24,70.19 R381.1 ; 35.55,68.96 35.95,68.56 U84.D2
N17153703: length 2.5
  BOTTOM w0.14: R380.1 36.51,70.24 36.4,70.13 C393.1 36.4,68.38 U84.D3
N17153749: length 3.2
  BOTTOM w0.14: 3.1,73.16 3.33,73.16 3.5,72.99 U82.D2 ; 3.1,73.16 3.03,73.24 C385.2 3.03,74.38 2.88,74.53 R376.1 ; 3.1,73.16 U82.D1
N17153787: length 3.3
  BOTTOM w0.14: R379.1 40.01,70.33 40.17,70.17 C392.2 40.17,69.08 40.3,68.96 ; 40.3,68.96 40.7,68.56 U83.D2 ; 40.3,68.96 U83.D1
N17153799: length 3.3
  BOTTOM w0.14: R383.1 30.74,70.29 30.88,70.14 C394.2 30.88,69.08 31.01,68.96 ; 31.01,68.96 31.41,68.56 U85.D2 ; 31.01,68.96 U85.D1
N17153878: length 1.5
  BOTTOM w0.14: R385.1 37.29,66.95 36.53,66.95 U84.A3
N17153949: length 1.4
  BOTTOM w0.14: U82.A3 3.93,71.49 R377.1
N17153951: length 1.5
  BOTTOM w0.14: R386.1 42.12,66.95 41.28,66.95 U83.A3
N17154063: length 1.3
  BOTTOM w0.14: R387.1 31.99,66.95 U85.A3
N17167245: length 2
  BOTTOM w0.14: R348.2 55.96,95.51 56.21,95.77 56.7,95.77 56.82,95.64 U78.32
N17253632: length 7.6
  BOTTOM w0.14: R563.2 44.75,16.04 45.28,16.57 48.61,16.57 48.94,16.23 L11.2
  vias: v1(49.93,12.3) v1(50.72,12.73)
N17253649: length 2.5
  BOTTOM w0.254: U120.9 46.28,14.59 L11.1
N17253673: length 2.7
  BOTTOM w0.14: U120.7 45.28,12.96 R563.1 TP106.1
N17253694: length 2.3
  BOTTOM w0.14: R569.2 45.36,8.68 45.48,8.8 45.48,9.48 45.78,9.79 U120.3
N17269599: length 2
  TOP w0.14: U41.6 64.55,43.25 R176.1 R173.2
N17275147: length 1.3
  BOTTOM w0.14: R407.2 U86.3
N17285208: length 12.2
  L10_SIG03 w0.102: v1(4.63,118.89) 3.62,117.88 3.62,114.71 v1(1.64,112.73)
  BOTTOM w0.14: U58.5 R317.1 1.29,113.08 v1(1.64,112.73) ; U58.12 4.21,117.86 4.63,118.28 v1(4.63,118.89)
N17370891: length 1.6
  BOTTOM w0.14: R413.2 18.66,49.45 18.58,49.37 U90.17
N17378539: length 2.1
  TOP w0.14: LD8.1 20.69,23.11 R228.2
N17479799: length 1.3
  BOTTOM w0.14: R507.2 78.67,23.27 U105.8
N17479805: length 4
  BOTTOM w0.254: C458.2 75.89,26.86 75.97,26.77 R488.2 R487.1 U105.5
N17479881: length 3.3
  TOP w0.14: R202.1 68.2,26.21 67.96,25.97 C144.2 67.95,25.56 67.66,25.28 67.66,25.07 67.17,24.57 U47.68
N17481587: length 1.6
  TOP w0.14: LD9.2 51.12,9.08 51.27,8.93 R236.2
N17481598: length 3.8
  TOP w0.203: U47.96 55.97,24.62 55.36,25.23 C143.2
  TOP w0.254: C143.2 55.43,25.28 55.84,25.28 v1(55.93,25.37)
  BOTTOM w0.254: v1(55.93,25.37) 55.93,25.02 56.19,24.76 R496.2
N17481613: length 2.1
  TOP w0.14: R204.1 56.68,25.14 56.37,24.82 U47.95
N17481619: length 6.6
  TOP w0.14: U47.1 55.97,7.4 55.74,7.17 53.48,7.17 53.02,7.64 R238.1 51.08,7.64 R237.2
N17481621: length 3.8
  TOP w0.14: R231.2 v1(71.53,19.63) 71.53,20.15 71.06,20.63 U47.60
  BOTTOM w0.14: R231.2 v1(71.53,19.63)
N17481627: length 2.1
  TOP w0.14: R240.1 56.57,7.06 56.77,7.26 U47.3
N17481631: length 1.1
  TOP w0.14: R240.2 LD10.2
N17481633: length 4.8
  TOP w0.14: R225.2 71.76,23.44 71.53,23.22 v1(71.53,22.73) 71.16,22.36 71.16,22.08 70.9,21.83 U47.63
  BOTTOM w0.14: v1(71.53,22.73) 71.53,23.17 71.81,23.44 R225.2
N17481635: length 3.1
  TOP w0.14: R230.2 v1(71.53,20.9) 71.41,21.03 U47.61
  BOTTOM w0.14: R230.2 v1(71.53,20.9)
N17481637: length 5.6
  TOP w0.14: R236.1 55.16,8.93 55.69,9.46 56.94,9.46 57.17,9.23 U47.4
N17481641: length 3.5
  TOP w0.14: R229.2 71.89,22.17 v1(71.53,21.82) 71.14,21.43 U47.62
  BOTTOM w0.14: R229.2 71.89,22.17 v1(71.53,21.82)
N17492093: length 1.1
  TOP w0.14: R40.2 29.27,125.37 U10.5
N17492111: length 1.8
  BOTTOM w0.14: R392.1 J10.1
N17498937: length 4
  BOTTOM w0.14: R405.2 80.1,52.66 80.1,52.51 78.91,51.32 78.91,50.82 78.46,50.37 77.99,50.37 U88.2
N17498940: length 3
  BOTTOM w0.14: U88.1 78.2,50.79 78.54,51.13 78.54,51.46 79.41,52.33 R406.2
N17653582: length 1.3
  BOTTOM w0.14: R327.2 81.11,104.66 Q5.3
N17726648: length 2.7
  TOP w0.254: D2.3 R134.2 R135.1
N17796705: length 0.9
  BOTTOM w0.14: Q6.3 78.86,82.73 R364.2
N17796716: length 1
  BOTTOM w0.14: Q7.3 81.52,82.08 R365.2
N17824845: length 1.7
  BOTTOM w0.14: U90.36 24.31,44.96 24.41,44.85 24.91,44.85 R426.1
N17824852: length 1.6
  BOTTOM w0.14: R431.1 24.73,44.4 24.58,44.56 U90.37
N17824859: length 1.7
  BOTTOM w0.14: R436.1 24.9,43.64 24.39,44.16 U90.38
N17824866: length 1.7
  BOTTOM w0.14: U90.39 24.31,43.76 24.69,43.38 R439.1
N17827086: length 2.4
  BOTTOM w0.14: R393.2 R395.2 J11.1
N17827089: length 2.4
  BOTTOM w0.14: J11.3 R396.2 R394.2
N17850096: length 9.8
  L05_SIG02 w0.381: v1(18.47,27.29) 17.68,28.08 17.68,31.36 v1(15.62,33.41)
  BOTTOM w0.254: Q11.3 18.04,28.62 17.93,28.51 C455.2 R485.2 v1(18.47,27.29)
N17935978: length 3.7
  BOTTOM w0.14: R453.1 R449.2 ; R453.1 Q9.3 ; R453.1 R446.2
N18121816: length 3.4
  BOTTOM w0.14: R261.1 J21.2
N18121892: length 3.4
  BOTTOM w0.14: R260.1 J21.4
N18121904: length 3.4
  BOTTOM w0.14: R259.1 J21.6
N18121916: length 3.4
  BOTTOM w0.14: R244.2 J21.9
N18121928: length 3.4
  BOTTOM w0.14: R258.1 J21.12
N18121940: length 3.4
  BOTTOM w0.14: R257.1 J21.14
N18374804: length 2.9
  BOTTOM w0.14: R545.2 56.16,15.86 56.25,15.77 J23.36
N18374807: length 3.1
  BOTTOM w0.14: R549.2 54.97,15.74 55.23,15.47 55.23,14.69 55.75,14.18 J23.37
N18374810: length 3.5
  BOTTOM w0.14: J23.38 55.25,14.22 53.73,15.74 R550.2
N18374813: length 5
  BOTTOM w0.14: J23.39 54.75,14.19 54.11,14.82 51.95,14.82 51.46,15.31 R551.2
N18516151: length 1.1
  TOP w0.14: U25.A3 1.68,89.88 R109.1
N18520654: length 1
  TOP w0.14: U17.A3 5.8,105.66 5.26,105.66 5.25,105.65 R67.1
N18571509: length 1.8
  BOTTOM w0.14: R568.2 31.14,9.15 30.85,8.86 U123.5
N18571515: length 2.1
  BOTTOM w0.14: U123.4 29.72,9.54 29.87,9.69 30.82,9.69 R565.1
N18576337: length 1.8
  BOTTOM w0.14: U78.39 59.15,99.11 58.75,99.51 58.75,99.71 R342.2
N18576340: length 1.7
  BOTTOM w0.14: R341.2 59.4,99.39 59.65,99.15 U78.40
N18736007: length 2.6
  BOTTOM w0.254: U88.14 76.66,43.31 C426.2
N18736028: length 1.6
  BOTTOM w0.254: U88.13 77.16,44.02 77.69,43.49 R437.2
N19082749: length 1.6
  TOP w0.14: R42.1 24.82,125.48 U9.3
N19361712: length 2.7
  TOP w0.14: LD7.1 v1(27.51,23.68)
  BOTTOM w0.14: Q12.3 27.64,24.71 27.53,24.59 27.53,23.69 v1(27.51,23.68)
N19806973: length 1.2
  BOTTOM w0.14: U114.7 50.65,19.09 51.06,18.68 R529.2
N20199452: length 2.4
  TOP w0.254: D1.3 R124.2 R125.1
N20506305: length 1.1
  TOP w0.356: U43.11 24.46,30.77 24.71,30.52
N20506307: length 1.2
  TOP w0.33: U43.9 23.46,30.62 23.31,30.46
N20506388: length 1.7
  TOP w0.14: U43.6 21.95,32.56 21.81,32.7 v1(21.81,32.92)
  BOTTOM w0.132: R469.1 22.09,33.2 v1(21.81,32.92)
N20506390: length 1.2
  TOP w0.14: U43.2 24.21,34.1 24.36,34.24 R197.1
N20506392: length 1.2
  TOP w0.14: U43.1 24.71,33.97 R199.2
N20506511: length 1.4
  TOP w0.14: C136.1 23.47,34.33 23.71,34.08 U43.3
N20878915: length 1.8
  TOP w0.14: R16.2 44.96,145.72 44.72,145.48 U5.1
N20878927: length 1.8
  TOP w0.14: U5.2 44.07,145.58 44.19,145.71 R15.1
N20878931: length 2.1
  TOP w0.14: U5.11 42.77,137.01 R32.2
N20900570: length 1.6
  TOP w0.14: R35.1 50.7,135.08 U7.3
N20900572: length 2.5
  TOP w0.14: U7.8 56.75,136.38 56.32,136.81 R26.1
N20900574: length 2.4
  TOP w0.14: R37.1 56.45,134.08 56.8,134.43 U7.5
N20900809: length 1.5
  TOP w0.14: U7.7 58.68,135.73 58.79,135.62 R34.1
N20933818: length 1.3
  TOP w0.14: U54.4 23.62,37.4 24.02,37 R283.2
N20933822: length 1.9
  TOP w0.14: R285.1 25.04,37.45 24.68,37.81 U54.5
N20936712: length 2.2
  TOP w0.132: R159.2 63.19,50.22 63.22,50.19 J12.2
N21016640: length 3.2
  TOP w0.14: TP24.1 65.55,99.28 v1(65.53,99.3)
  BOTTOM w0.14: v1(65.53,99.3) 65.1,98.87 63.86,98.87 63.65,98.66 U78.48
N21068099: length 1.4
  TOP w0.14: U30.1 65.15,73.86 R130.2
N21079949: length 2.5
  TOP w0.14: v1(64.14,90.31) 63.68,90.77 TP27.1
  BOTTOM w0.14: U78.14 63.15,90.92 63.37,90.7 63.75,90.7 v1(64.14,90.31)
N21197992: length 2.7
  TOP w0.14: U2.16 52.01,146.41 52.28,146.14 TP7.1
N21197993: length 1.5
  TOP w0.14: TP4.1 51.51,146.04 U2.15
N21197994: length 1.5
  TOP w0.14: TP3.1 50.51,146.04 U2.13
N21197995: length 2.6
  TOP w0.14: TP6.1 U2.14
N21197996: length 2.7
  TOP w0.14: TP5.1 49.74,146.08 50.01,146.35 U2.12
N21198784: length 1.6
  TOP w0.14: TP2.1 49.1,146.15 49.51,146.55 U2.11
N22124383: length 2.4
  TOP w0.14: U12.A5 46.09,119.13 R50.2
N22156088: length 1.7
  BOTTOM w0.14: R478.2 70.93,31.12 U99.7
N22156090: length 1.7
  BOTTOM w0.14: R476.2 U99.6
N22373538: length 6.8
  TOP w0.14: R139.1 2.78,68.25 2.66,68.37 U31.2 2.66,70.43 2.39,70.7 2.39,71.49 3.66,72.76 U31.7
N22424368: length 1.2
  BOTTOM w0.14: C432.1 37.72,41.14 37.58,41.28 R441.2
N22424482: length 29.5
  TOP w0.14: Q2.4 44.95,43.81 45.79,44.66 45.79,47.73 46.42,48.36 v1(46.83,48.36)
  L10_SIG03 w0.102: v1(46.83,48.36) 46.32,48.36 44.99,47.03 41.62,47.03 41.32,47.33 41.32,48.78 40.66,49.44 32.21,49.44 v1(29.98,47.22)
  BOTTOM w0.14: R417.2 30.46,48.45 R418.2 v1(29.98,47.22)
N22441821: length 1
  BOTTOM w0.14: R329.2 70.57,104.63 U63.3
N22441998: length 1.4
  BOTTOM w0.14: R361.2 60.63,84.29 60.99,84.29 61.3,84.6 U81.1
N22442187: length 1
  BOTTOM w0.14: U65.3 66.64,105.1 R325.2
N22498870: length 2
  TOP w0.14: R178.2 R182.1 64.88,39.77 U42.6
N22682365: length 1.9
  TOP w0.14: LD4.2 15.73,51.58 R160.2
N22685157: length 4.3
  TOP w0.14: LD2.1 5.76,63.34 4.39,64.71 v1(3.05,64.71)
  BOTTOM w0.14: Q8.3 v1(3.05,64.71)
N22685161: length 1.9
  TOP w0.14: R143.1 6.33,61.75 LD2.2
N22685196: length 2
  BOTTOM w0.14: R384.2 1.95,69.18 2.1,69.03 Q8.1
N22685214: length 1.6
  TOP w0.254: R150.1 LD3.2
N22685551: length 1.6
  TOP w0.14: v1(15.23,109.23) 15,108.99 LD1.1
  BOTTOM w0.14: Q4.6 15.31,109.15 v1(15.23,109.23)
N22685595: length 1.1
  BOTTOM w0.14: Q4.3 17.88,107.54 18.17,107.83 R323.2
N22685622: length 1.7
  TOP w0.14: R62.1 LD1.2
N22685670: length 2.4
  TOP w0.132: R163.2 53.97,49.9 54.35,50.29 Q1.3
N22685686: length 2.2
  TOP w0.14: R162.1 LD5.2
N22734804: length 4
  TOP w0.14: J2.32 8.46,142.29 v1(8.4,142.23)
  BOTTOM w0.14: v1(8.4,142.23) 8.02,142.61 7.01,142.61 6.76,142.36 R254.1
N22816067: length 1.7
  TOP w0.14: J2.62 R8.1
N22885689: length 1.7
  TOP w0.14: v1(18.59,75.01) 18.74,75.16 U27.53
  BOTTOM w0.14: v1(18.59,75.01) 18.59,75.14 18.65,75.2 R374.2
N23161423: length 2.4
  TOP w0.14: v1(64.23,25.5) 64.23,25.5 64.37,25.36 U47.75
  BOTTOM w0.14: v1(64.23,25.5) 64.27,25.55 R493.1
N23178593: length 2.3
  BOTTOM w0.14: U102.6 60.04,27.64 59.93,27.52 TP104.1
N23178631: length 1.4
  BOTTOM w0.14: U102.3 63.19,27.64 TP105.1
N23178675: length 1.9
  BOTTOM w0.14: U55.14 57.67,135.75 TP96.1
N23178691: length 2
  BOTTOM w0.14: U55.13 59.08,136.44 TP94.1
N23178707: length 2.5
  BOTTOM w0.14: U55.12 58.95,137.09 TP93.1
N23233575: length 2.2
  TOP w0.254: C507.1 22.22,97.58 v1(21.99,97.58) 21.89,97.58 U21.B1
  BOTTOM w0.381: v1(21.99,97.58) 22.17,97.77 R95.1
N23413104: length 1.3
  TOP w0.14: R44.1 21.53,124.08 21.73,124.28 U9.1
N23415089: length 1.2
  BOTTOM w0.14: U86.1 R399.2
N23696264: length 2.4
  BOTTOM w0.14: U87.5 46.24,52.89 R576.2 R410.2
N23989710: length 2
  BOTTOM w0.14: U125.32 56.82,118.2 56.7,118.33 56.21,118.33 55.96,118.07 R582.2
N23995034: length 1.8
  BOTTOM w0.14: U125.39 59.15,121.67 58.75,122.06 58.75,122.26 R586.2
N23995036: length 1.7
  BOTTOM w0.14: R584.2 59.4,121.95 59.65,121.7 U125.40
N23995224: length 8.9
  BOTTOM w0.14: R585.2 73.71,126.74 74.01,126.45 76.19,126.45 76.62,126.01 79.11,126.01 80.85,124.28 J24.11
N23996283: length 1
  BOTTOM w0.14: R588.2 78.22,104.69 U127.3
N23996295: length 1
  BOTTOM w0.14: U126.3 64.3,110.35 R587.2
N23996384: length 1.4
  BOTTOM w0.14: U128.3 75.21,126.96 R591.2
N23997204: length 3.2
  TOP w0.14: v1(65.53,121.86) 65.55,121.84 TP123.1
  BOTTOM w0.14: U125.48 63.65,121.22 63.86,121.43 65.1,121.43 v1(65.53,121.86)
N23997231: length 1.5
  TOP w0.14: v1(64.16,113.95) TP124.1
  BOTTOM w0.14: v1(64.16,113.95) U125.13
N24012713: length 2.5
  TOP w0.14: v1(64.14,112.86) 63.68,113.32 TP125.1
  BOTTOM w0.14: U125.14 63.15,113.48 63.37,113.25 63.75,113.25 v1(64.14,112.86)
N193617400: length 1.3
  BOTTOM w0.14: Q12.1 R500.2
N193617480: length 1
  TOP w0.14: LD7.2 R222.1

## Copper pours and planes (outline as drawn)
DGND on L03_SIG01 (solid shape): 10.1,84.94 10.13,84.96 10.16,84.95 10.17,84.95 10.19,84.92 10.19,84.45 10.19,84.43 10.18,84.41 9.11,83.34 9.08,83.33 9.05,83.33 9.04,83.34 9.02,83.36 9.02,83.84 9.02,83.86 9.03,83.87
DGND on L03_SIG01 (solid shape): 10.81,58.4 10.83,58.4 10.85,58.39 11.21,58.02 11.23,58 11.22,57.97 11.22,57.95 11.19,57.93 8.85,57.93 8.83,57.94 8.81,57.95 8.44,58.32 8.43,58.34 8.43,58.37 8.44,58.39 8.46,58.4
DGND on L03_SIG01 (solid shape): 12.18,111.56 12.21,111.57 12.24,111.57 12.25,111.56 12.27,111.54 12.27,111.14 12.27,111.12 12.26,111.1 11.29,110.14 11.26,110.12 11.23,110.13 11.22,110.13 11.2,110.16 11.2,110.56 11.21,110.58 11.22,110.59
DGND on L03_SIG01 (solid shape): 21.64,119.42 21.66,119.43 21.69,119.43 21.71,119.42 21.72,119.4 21.72,115 21.72,114.98 21.71,114.96 21.3,114.56 21.28,114.54 21.25,114.54 21.23,114.55 21.21,114.58 21.21,118.97 21.22,118.99 21.23,119.01
DGND on L03_SIG01 (solid shape): 73.66,31.69 74.69,30.66 74.7,30.65 74.7,30.63 74.7,27.9 74.69,27.87 74.67,27.86 74.66,27.85 74.63,27.86 73.6,28.88 73.59,28.9 73.59,28.92 73.59,31.64 73.6,31.67 73.62,31.69 73.63,31.7
DGND on L03_SIG01 (solid shape): 18.38,54.63 18.81,54.2 18.83,54.19 18.85,54.18 21.04,54.18 21.06,54.18 21.08,54.17 21.66,53.58 21.68,53.56 21.67,53.53 21.67,53.51 21.64,53.5 18.97,53.5 18.95,53.5 18.93,53.51 18.32,54.12 18.31,54.14 18.31,54.16 18.31,54.58 18.32,54.61 18.34,54.63 18.35,54.64
DGND on L03_SIG01 (solid shape): 22.29,96.8 22.32,96.8 22.34,96.77 22.34,96.76 22.34,96.73 21.89,96.28 21.88,96.27 21.87,96.25 21.87,88.54 21.87,88.52 21.86,88.5 21.65,88.29 21.62,88.28 21.59,88.28 21.58,88.29 21.56,88.31 21.56,96.45 21.56,96.47 21.58,96.49 21.88,96.79 21.9,96.8 21.91,96.8
DGND on L03_SIG01 (solid shape): 8.51,90.9 8.53,90.91 8.56,90.91 8.58,90.9 8.59,90.88 8.59,86.94 8.6,86.93 8.61,86.91 8.91,86.6 8.92,86.57 8.92,86.55 8.91,86.54 8.87,86.52 8.83,86.54 8.24,87.13 8.23,87.15 8.22,87.17 8.22,90.59 8.23,90.61 8.24,90.63
DGND on L03_SIG01 (solid shape): 5.49,137.13 5.52,137.15 5.55,137.14 5.56,137.14 5.58,137.11 5.58,135.14 5.57,135.11 5.55,135.09 5.46,135.04 5.44,135.04 5.42,135.05 5.28,135.09 5.12,135.06 5.11,135.06 5.09,135.06 5,135.11 4.99,135.13 4.98,135.15 4.98,136.6 4.99,136.62 5,136.64
DGND on L03_SIG01 (solid shape): 29.94,104.35 29.97,104.34 29.99,104.32 29.99,104.3 29.99,104.27 28.48,102.77 28.46,102.75 28.44,102.75 28.1,102.75 28.09,102.75 28.07,102.74 27.9,102.57 27.89,102.56 27.87,102.56 27.78,102.56 27.72,102.62 27.67,102.66 27.66,102.67 27.65,102.76 27.65,102.79 27.67,102.8 29.2,104.33 29.21,104.35 29.23,104.35
DGND on L03_SIG01 (solid shape): 38.7,123.84 38.73,123.83 38.75,123.8 38.75,123.79 38.75,123.76 38.43,123.45 38.42,123.44 38.4,123.43 32.08,123.43 32.06,123.44 32.05,123.45 31.99,123.51 31.98,123.58 31.97,123.63 31.98,123.65 32.04,123.72 32.05,123.74 32.08,123.74 34.47,123.74 34.49,123.74 34.51,123.76 34.57,123.82 34.59,123.83 34.61,123.84
DGND on L03_SIG01 (solid shape): 26.11,108.13 26.14,108.12 26.16,108.1 26.17,108.08 26.16,108.05 26,107.89 25.99,107.88 25.99,107.86 25.99,107.54 25.98,107.52 25.97,107.51 24.97,106.51 24.95,106.49 24.93,106.49 24.84,106.49 24.81,106.5 24.79,106.52 24.78,106.54 24.79,106.57 25.49,107.27 25.5,107.28 25.5,107.3 25.5,107.63 25.51,107.65 25.52,107.67 25.96,108.11 25.98,108.12 26,108.13
DGND on L03_SIG01 (solid shape): 33.41,47.66 33.43,47.68 33.46,47.67 33.48,47.67 33.49,47.64 33.49,40.07 33.5,40.05 33.51,40.03 33.81,39.73 33.82,39.71 33.82,39.69 33.82,38.72 33.82,38.7 33.81,38.68 33.44,38.32 33.41,38.3 33.38,38.31 33.37,38.31 33.35,38.34 33.35,43.22 33.35,43.24 33.34,43.25 32.97,43.62 32.96,43.64 32.95,43.66 32.95,47.19 32.96,47.21 32.97,47.23
DGND on L03_SIG01 (solid shape): 36.21,25.65 36.24,25.67 36.27,25.66 36.28,25.66 36.3,25.63 36.3,22.9 36.29,22.88 36.28,22.86 35.12,21.7 35.1,21.68 35.08,21.68 34.28,21.68 34.27,21.68 34.25,21.67 34.15,21.56 34.12,21.55 34.09,21.55 34.08,21.56 34.06,21.58 34.06,23.25 34.06,23.27 34.07,23.29 36.11,25.32 36.12,25.34 36.12,25.35 36.12,25.54 36.13,25.56 36.14,25.58
DGND on L03_SIG01 (solid shape): 22.4,49.01 22.43,49.02 22.46,49.02 22.47,49.01 22.49,48.99 22.49,48.79 22.49,48.77 22.48,48.76 22.17,48.45 22.16,48.44 22.15,48.42 22.15,41.23 22.13,41.21 22.08,41.19 22.03,41.17 22,41.18 21.92,41.23 21.9,41.25 21.9,41.27 21.9,41.59 21.89,41.61 21.88,41.63 21.69,41.82 21.68,41.84 21.67,41.86 21.67,48.26 21.68,48.28 21.69,48.3
DGND on L03_SIG01 (solid shape): 45.16,91.35 45.19,91.36 45.22,91.36 45.23,91.35 45.25,91.33 45.25,90.86 45.25,90.84 45.26,90.82 45.87,90.21 45.88,90.2 45.89,90.18 45.89,89.83 45.88,89.81 45.87,89.8 45.46,89.39 45.43,89.37 45.41,89.38 45.39,89.38 45.37,89.41 45.37,90.11 45.37,90.13 45.36,90.15 44.46,91.05 44.44,91.08 44.45,91.1 44.45,91.12 44.48,91.14 44.93,91.14 44.95,91.14 44.97,91.15
DGND on L03_SIG01 (solid shape): 55.9,40.42 55.92,40.41 55.93,40.4 57.21,39.12 57.23,39.1 57.22,39.07 57.18,38.97 57.16,38.95 57.14,38.95 56.95,38.89 56.83,38.73 56.82,38.71 56.8,38.7 56.71,38.68 56.68,38.68 56.66,38.69 56.29,39.05 56.28,39.07 56.28,39.09 56.28,39.71 56.28,39.73 56.26,39.74 55.68,40.33 55.66,40.36 55.67,40.38 55.67,40.4 55.7,40.42
DGND on L03_SIG01 (solid shape): 28.8,121.34 28.83,121.34 28.85,121.31 28.86,121.3 28.85,121.27 28.54,120.96 28.53,120.95 28.51,120.95 27.71,120.95 27.69,120.94 27.67,120.93 26.86,120.12 26.84,120.11 26.82,120.1 26.73,120.11 26.71,120.12 26.66,120.18 26.6,120.22 26.59,120.24 26.58,120.33 26.58,120.36 26.59,120.38 26.99,120.77 27,120.79 27.01,120.81 27.01,121.27 27.01,121.29 27.02,121.31 27.04,121.33 27.06,121.34 27.08,121.34
DGND on L03_SIG01 (solid shape): 33,37.93 33.02,37.94 33.05,37.94 33.07,37.93 33.09,37.91 33.09,37.15 33.08,37.13 33.07,37.11 32.5,36.54 32.49,36.53 32.49,36.49 32.47,36.46 32.44,36.44 32.42,36.44 32.4,36.46 32.39,36.47 32.22,36.6 32,36.59 31.99,36.59 31.97,36.59 31.89,36.64 31.87,36.66 31.87,36.69 31.87,36.78 31.87,36.8 31.88,36.81
DGND on L03_SIG01 (solid shape): 23.48,107.98 23.55,107.93 23.57,107.91 23.57,107.89 23.57,107.37 23.57,107.35 23.59,107.33 23.93,106.99 23.95,106.98 23.97,106.97 24.35,106.97 24.38,106.96 24.4,106.94 24.41,106.93 24.4,106.9 24.35,106.84 24.33,106.83 24.31,106.83 23,106.83 22.96,106.84 22.95,106.88 22.95,107.55 22.94,107.57 22.92,107.6 22.91,107.63 22.92,107.67 23.23,107.97 23.26,107.98 23.27,107.98 23.36,107.97 23.44,107.98 23.45,107.99
DGND on L03_SIG01 (solid shape): 14.95,94.92 15.02,94.86 15.03,94.85 15.04,94.82 15.04,93.81 15.04,93.79 15.02,93.77 14.91,93.65 14.89,93.64 14.87,93.64 14.78,93.65 14.76,93.66 14.75,93.67 14.46,93.81 14.19,93.64 14.18,93.63 14.16,93.62 13.65,93.62 13.63,93.62 13.61,93.65 13.6,93.66 13.61,93.69 14.82,94.9 14.88,94.91 14.92,94.92
DGND on L03_SIG01 (solid shape): 26.34,112.38 26.36,112.39 26.39,112.39 26.41,112.38 26.42,112.36 26.42,111.59 26.42,111.57 26.41,111.55 25.53,110.67 25.51,110.66 25.49,110.65 25.27,110.65 25.24,110.66 25.22,110.68 25.22,110.7 25.22,110.73 25.38,110.88 25.4,110.89 25.63,111.04 25.67,111.31 25.67,111.32 25.67,111.35 25.74,111.44 25.75,111.44 26.12,111.81 26.13,111.82 26.13,111.84 26.13,112.15 26.13,112.17 26.15,112.18
DGND on L03_SIG01 (solid shape): 2.38,95.2 3.01,94.57 3.03,94.56 3.05,94.55 3.95,94.55 3.97,94.55 3.98,94.54 4.56,93.96 4.58,93.95 4.6,93.94 6.06,93.94 6.08,93.94 6.1,93.92 6.16,93.85 6.16,93.83 6.16,93.82 6.15,93.68 6.21,93.55 6.21,93.54 6.22,93.51 6.17,93.42 6.15,93.4 6.12,93.39 3.19,93.39 3.17,93.4 3.15,93.41 2.25,94.31 2.24,94.33 2.23,94.35 2.23,95.11 2.24,95.13 2.25,95.15 2.32,95.21 2.34,95.21
DGND on L03_SIG01 (solid shape): 29.49,22.64 29.51,22.62 29.52,22.59 29.52,22.53 29.52,22.51 29.53,22.5 30.14,21.89 30.15,21.88 30.15,21.86 30.15,16.19 30.14,16.17 30.12,16.15 30.1,16.14 30.08,16.15 29.32,16.9 29.31,16.92 29.3,16.94 29.3,18.21 29.31,18.23 29.32,18.25 29.63,18.56 29.64,18.58 29.64,18.6 29.64,21.95 29.64,21.97 29.63,21.99 29.19,22.43 29.18,22.45 29.18,22.48 29.2,22.58 29.22,22.59 29.29,22.63 29.35,22.67 29.36,22.68 29.39,22.68
DGND on L03_SIG01 (solid shape): 26.76,54.21 26.85,54.16 26.87,54.14 26.88,54.11 26.88,51.27 26.87,51.25 26.86,51.23 25.95,50.32 25.94,50.31 25.94,50.29 25.94,48.88 25.93,48.86 25.92,48.84 25.85,48.78 25.75,48.78 25.67,48.76 25.64,48.76 25.57,48.82 25.55,48.84 25.55,48.86 25.55,50.82 25.55,50.84 25.56,50.86 26.28,51.58 26.29,51.59 26.29,51.61 26.29,54.1 26.3,54.12 26.31,54.14 26.4,54.2 26.42,54.2 26.43,54.19 26.58,54.16 26.73,54.2 26.74,54.21
DGND on L03_SIG01 (solid shape): 27.86,11.56 27.88,11.58 27.91,11.57 27.93,11.57 27.94,11.54 27.94,10.83 27.95,10.81 27.96,10.8 28.11,10.65 28.12,10.63 28.12,10.61 28.12,8.64 28.13,8.62 28.14,8.61 29.8,6.94 29.81,6.92 29.89,6.74 30.06,6.64 30.09,6.63 30.1,6.6 30.09,6.56 30.06,6.53 30.05,6.52 30.03,6.52 29.09,6.52 29.07,6.52 29.05,6.53 26.81,8.77 26.8,8.78 26.8,8.8 26.8,10.49 26.8,10.51 26.81,10.52
DGND on L03_SIG01 (solid shape): 55.35,117.65 55.38,117.66 55.41,117.66 55.42,117.65 55.44,117.63 55.44,117.33 55.44,117.31 55.43,117.29 54.85,116.72 54.84,116.72 54.63,116.79 54.42,116.72 54.4,116.71 54.36,116.71 54.12,116.95 54.1,116.99 54.12,117.03 54.13,117.03 54.15,117.04 54.2,117.03 54.24,117.03 54.38,117.03 54.48,117.05 54.56,117.1 54.73,117.27 54.74,117.29 54.74,117.31 54.74,117.42 54.75,117.45 54.76,117.46 54.84,117.52 54.87,117.52 54.92,117.51 54.96,117.5 55.19,117.5 55.21,117.51 55.23,117.52
DGND on L03_SIG01 (solid shape): 15.94,55.22 16.7,54.47 16.71,54.45 16.71,54.43 16.71,51.17 16.68,51.11 16.66,51.1 16.57,51.09 16.55,51.09 16.53,51.1 15.88,51.75 15.87,51.77 15.87,51.79 15.87,53.83 15.87,53.85 15.88,53.87 15.95,53.92 15.97,53.93 15.99,53.93 16.37,54.25 15.99,54.58 15.97,54.58 15.95,54.58 15.88,54.64 15.87,54.66 15.87,54.68 15.87,55.18 15.88,55.2 15.9,55.22 15.91,55.23
DGND on L03_SIG01 (solid shape): 34.51,97.78 34.62,97.74 34.73,97.74 34.74,97.74 34.77,97.73 35.09,97.41 35.11,97.4 35.13,97.39 35.56,97.39 35.59,97.38 35.61,97.34 35.61,96.1 35.6,96.08 35.59,96.06 35.53,96 35.43,96 35.37,96.06 35.36,96.08 35.35,96.1 35.35,96.73 35.35,96.75 35.34,96.76 34.98,97.12 34.96,97.13 34.94,97.14 34.63,97.14 34.61,97.14 34.59,97.15 34.57,97.18 34.56,97.19 34.55,97.21 34.55,97.58 34.55,97.6 34.54,97.61 34.45,97.7 34.44,97.74 34.45,97.77 34.47,97.78 34.5,97.79
DGND on L03_SIG01 (solid shape): 38.98,34.06 39.01,34.08 39.03,34.08 39.13,34.05 39.15,34.03 39.15,34.02 39.25,33.86 39.42,33.77 39.44,33.77 39.46,33.75 39.49,33.65 39.49,33.63 39.48,33.6 38.8,32.93 38.79,32.91 38.79,32.89 38.79,28.97 38.78,28.95 38.77,28.93 35.68,25.84 35.66,25.83 35.64,25.82 35.56,25.83 35.53,25.84 35.45,25.9 35.35,25.94 35.34,25.94 35.32,25.96 35.29,26.06 35.28,26.09 35.3,26.11 36.79,27.6 36.8,27.62 36.81,27.64 36.81,32.58 36.81,32.6 36.82,32.61 37.43,33.22 37.45,33.23 37.47,33.24 38.14,33.24 38.16,33.24 38.17,33.25
DGND on L03_SIG01 (solid shape): 52.14,98.18 52.18,98.17 52.2,98.13 52.2,98.11 52.21,98.1 53.05,97.26 53.1,97.24 53.13,97.24 53.99,96.38 54,96.36 54,96.34 54,91.2 54.01,91.18 54.02,91.16 55.31,89.87 55.33,89.86 55.35,89.85 57.66,89.85 57.68,89.85 57.69,89.84 58.08,89.45 58.09,89.44 58.09,89.42 58.09,88.93 58.08,88.9 58.06,88.88 58.05,88.88 58.02,88.88 57.98,88.91 57.96,88.91 56.11,88.91 56.09,88.92 56.07,88.93 53.84,91.16 53.83,91.18 53.83,91.19 53.83,96.31 53.82,96.33 53.81,96.34 52.06,98.1 52.04,98.12 52.05,98.15 52.05,98.17 52.08,98.18
DGND on L03_SIG01 (solid shape): 73.56,27.56 73.58,27.56 73.61,27.55 73.63,27.53 73.64,27.51 73.73,27.32 73.92,27.23 73.94,27.22 73.98,27.18 73.99,27.16 73.99,27.14 73.99,26.15 73.99,26.13 73.98,26.11 73.53,25.67 73.51,25.65 73.49,25.65 73.4,25.66 73.38,25.67 73.37,25.68 73.22,25.8 73.03,25.82 73.02,25.81 73,25.82 72.93,25.88 72.91,25.89 72.91,25.91 72.91,27.25 72.91,27.27 72.93,27.29 73,27.34 73.03,27.35 73.04,27.34 73.27,27.36 73.44,27.52 73.45,27.53 73.47,27.55
DGND on L03_SIG01 (solid shape): 48.94,106.62 48.96,106.62 48.98,106.61 49.13,106.45 49.15,106.43 49.15,106.41 49.14,106.32 49.13,106.3 49.12,106.29 48.96,106.02 49.1,105.74 49.12,105.73 49.13,105.7 49.13,105.62 49.12,105.59 49.1,105.58 49.07,105.55 49.01,105.5 48.93,105.5 48.91,105.5 48.89,105.51 48.5,105.9 48.48,105.92 48.46,105.92 47.11,105.92 47.09,105.92 47.07,105.94 47.01,106 47.01,106.07 47.01,106.13 47.07,106.19 47.09,106.21 47.11,106.21 47.98,106.21 48,106.21 48.02,106.23 48.4,106.61 48.42,106.62 48.44,106.62
DGND on L03_SIG01 (solid shape): 23.14,53.2 23.45,52.89 23.46,52.87 23.46,52.85 23.44,52.75 23.42,52.73 23.41,52.72 23.2,52.37 23.5,52.08 23.51,52.08 23.54,52.07 23.58,51.96 23.58,51.94 23.56,51.91 22.97,51.32 22.96,51.3 22.96,51.28 22.96,50.8 22.95,50.78 22.94,50.76 22.86,50.71 22.83,50.71 22.82,50.71 22.74,50.73 22.66,50.73 22.63,50.74 22.57,50.8 22.56,50.81 22.55,50.83 22.55,51.77 22.56,51.79 22.57,51.81 23.05,52.29 23.06,52.3 23.06,52.32 23.06,53.16 23.07,53.18 23.09,53.2 23.11,53.21
DGND on L03_SIG01 (solid shape): 38.05,43.77 38.13,43.72 38.15,43.7 38.15,43.68 38.15,41.24 38.15,41.22 38.14,41.2 37.41,40.47 37.39,40.45 37.39,40.43 37.39,38.04 37.39,38.02 37.38,38 36.19,36.81 36.18,36.8 36.17,36.78 36.17,36.69 36.17,36.67 36.15,36.65 36.07,36.59 36.05,36.59 36.04,36.59 35.89,36.61 35.75,36.56 35.73,36.55 35.71,36.55 35.62,36.6 35.6,36.62 35.59,36.64 35.59,36.95 35.59,36.97 35.6,36.98 36.77,38.15 36.78,38.16 36.78,38.18 36.78,40.63 36.79,40.65 36.8,40.66 37.71,41.57 37.72,41.59 37.72,41.61 37.72,43.66 37.73,43.68 37.74,43.7 37.81,43.75 37.83,43.76 37.84,43.76 37.93,43.75 38.02,43.77 38.03,43.78
DGND on L03_SIG01 (solid shape): 63.99,88.39 64,88.38 64.02,88.34 64,88.31 63.18,87.48 63.16,87.47 63.14,87.47 61.85,87.47 61.84,87.46 61.82,87.45 60.6,86.23 60.54,86.22 60.49,86.2 60.47,86.2 60.39,86.26 60.37,86.28 60.37,86.3 60.37,86.51 60.36,86.53 60.35,86.55 59.26,87.64 59.24,87.66 59.24,87.69 59.26,87.78 59.27,87.8 59.28,87.81 59.43,87.96 59.46,88.18 59.45,88.19 59.46,88.21 59.51,88.28 59.53,88.3 59.55,88.3 60.05,88.3 60.07,88.3 60.09,88.29 60.41,87.97 60.42,87.96 60.44,87.95 63.45,87.95 63.47,87.96 63.49,87.97 63.89,88.37 63.97,88.39
DGND on L03_SIG01 (solid shape): 84.31,107.19 84.34,107.18 84.36,107.17 84.36,107.14 84.36,104.78 84.29,104.71 79.3,104.71 79.27,104.72 79.25,104.76 79.25,104.79 80.22,105.75 80.23,105.79 80.23,106.16 80.47,106.16 80.47,106.11 80.47,106.05 80.49,106 80.51,105.96 80.54,105.92 80.58,105.88 80.62,105.85 80.67,105.83 80.72,105.81 80.77,105.8 80.82,105.8 80.87,105.81 80.92,105.83 80.97,105.85 81.01,105.88 81.05,105.92 81.08,105.96 81.1,106 81.12,106.05 81.13,106.11 81.13,106.16 81.12,106.21 81.1,106.26 81.08,106.3 81.05,106.35 81.01,106.38 80.97,106.41 80.92,106.44 80.87,106.45 80.82,106.46 80.77,106.46 80.72,106.45 80.67,106.44 80.62,106.41 80.58,106.38 80.54,106.35 80.51,106.3 80.49,106.26 80.47,106.21 80.47,106.16 80.23,106.16 80.23,107.14 80.24,107.17 80.25,107.18 80.28,107.19
DGND on L03_SIG01 (solid shape): 22.44,119.44 22.46,119.46 22.49,119.46 22.5,119.45 22.52,119.42 22.52,119.38 22.53,119.36 22.54,119.34 22.82,119.06 22.83,119.05 22.82,119 22.72,118.9 22.7,118.88 22.7,118.86 22.7,114.08 22.7,114.06 22.68,114.04 22.62,113.98 22.59,113.98 22.27,113.81 22.3,113.45 22.31,113.42 22.31,113.27 22.31,113.25 22.29,113.24 22.23,113.18 22.2,113.17 22.11,113.16 22.02,113.12 22.01,113.12 21.99,113.12 21.88,113.17 21.87,113.2 21.87,113.21 21.53,113.55 21.52,113.57 21.52,113.59 21.52,114.03 21.52,114.05 21.53,114.07 22.22,114.75 22.23,114.77 22.23,114.79 22.23,119.22 22.24,119.24 22.25,119.26
DGND on L03_SIG01 (solid shape): 39.19,87.04 39.21,87.04 39.22,87.02 39.48,86.9 39.74,87.02 39.75,87.04 39.78,87.04 40.36,87.04 40.38,87.04 40.39,87.02 40.45,86.96 40.46,86.93 40.45,86.86 40.42,86.83 40.18,86.83 40.16,86.82 40.14,86.81 39.83,86.5 39.81,86.48 39.81,86.46 39.81,86.3 39.8,86.27 39.78,86.26 39.69,86.21 39.67,86.21 39.66,86.21 39.48,86.26 39.3,86.21 39.29,86.21 39.27,86.21 39.18,86.26 39.16,86.27 39.15,86.3 39.15,86.47 39.15,86.49 39.13,86.5 38.82,86.81 38.81,86.83 38.79,86.83 38.54,86.83 38.51,86.86 38.5,86.93 38.51,86.96 38.57,87.02 38.58,87.04 38.61,87.04
DGND on L03_SIG01 (solid shape): 27.18,102.26 27.21,102.2 27.25,102.15 27.25,102.11 25.9,100.75 25.88,100.74 25.86,100.74 25.5,100.74 25.49,100.74 25.47,100.72 24.17,99.42 24.16,99.41 24.15,99.39 24.15,97.57 24.15,97.55 24.14,97.54 24,97.39 23.97,97.38 23.94,97.38 23.85,97.41 23.83,97.43 23.82,97.45 23.34,97.67 23.27,97.14 23.29,97.13 23.29,97.1 23.25,97 23.23,96.97 23.21,96.96 22.56,96.96 22.53,96.97 22.51,96.99 22.51,97.01 22.51,97.04 23.82,98.34 23.83,98.36 23.83,98.38 23.83,99.49 23.84,99.51 23.85,99.53 26.58,102.27 26.6,102.28 26.62,102.28 27.16,102.28
DGND on L03_SIG01 (solid shape): 45.45,96.59 45.47,96.59 45.49,96.58 45.54,96.51 45.55,96.48 45.62,96.27 45.8,96.14 45.82,96.13 45.88,96.08 45.89,96.04 45.88,96.01 45.85,95.99 45.7,95.94 45.59,95.83 45.59,95.83 45.18,95.41 45.17,95.4 45.16,95.38 45.16,95.02 45.15,94.99 45.11,94.97 44.94,94.97 44.92,94.98 44.9,94.99 44.34,95.55 44.32,95.56 44.3,95.56 43.91,95.56 43.89,95.57 43.88,95.58 43.82,95.64 43.82,95.71 43.87,95.78 43.89,95.79 43.91,95.79 44.56,95.79 44.58,95.8 44.59,95.81 44.94,96.15 44.95,96.17 44.95,96.19 44.95,96.51 44.96,96.53 44.97,96.55 45,96.58 45.01,96.59 45.03,96.59
DGND on L03_SIG01 (solid shape): 50.27,106.11 50.28,106.09 50.55,105.86 50.88,106.01 50.88,106.02 50.9,106.04 50.99,106.05 51.02,106.04 51.04,106.03 51.39,105.68 51.41,105.67 51.43,105.66 51.54,105.66 51.56,105.66 51.58,105.65 52.26,104.97 52.27,104.95 52.27,104.92 52.26,104.9 52.24,104.89 49.54,104.89 49.52,104.89 49.49,104.92 49.48,104.94 49.49,105.03 49.51,105.05 49.62,105.32 49.48,105.58 49.46,105.59 49.46,105.62 49.46,105.7 49.46,105.73 49.59,105.87 49.62,106.03 49.63,106.06 49.69,106.12 49.7,106.13 49.72,106.13 50.25,106.13
DGND on L03_SIG01 (solid shape): 57.05,22.03 57.06,22.02 57.19,21.89 57.38,21.85 57.41,21.84 57.47,21.78 57.48,21.77 57.49,21.75 57.49,20.54 57.48,20.52 57.47,20.51 57.29,20.32 57.27,20.31 57.24,20.31 57.15,20.32 57.13,20.33 57.13,20.34 56.61,20.4 56.67,19.88 56.68,19.88 56.69,19.86 56.71,19.77 56.7,19.75 56.69,19.73 56.49,19.52 56.46,19.51 56.43,19.51 56.42,19.52 56.4,19.54 56.4,21.75 56.41,21.77 56.42,21.79 56.49,21.85 56.51,21.85 56.52,21.85 56.73,21.88 56.88,22.02 56.88,22.03 56.91,22.05 57.03,22.05
DGND on L03_SIG01 (solid shape): 58.28,90.12 58.3,90.12 58.31,90.11 58.8,89.62 58.82,89.61 58.84,89.61 60.39,89.61 60.41,89.6 60.43,89.59 60.64,89.38 60.65,89.36 60.66,89.34 60.66,88.94 60.6,88.83 60.58,88.75 60.58,88.73 60.56,88.71 60.46,88.67 60.44,88.67 60.41,88.68 60.3,88.8 60.28,88.81 60.26,88.81 59.43,88.81 59.41,88.82 59.39,88.83 59.34,88.9 59.33,88.92 59.33,88.93 59.11,89.3 58.71,89.13 58.7,89.12 58.66,89.1 58.63,89.12 58.6,89.15 58.6,89.17 58.6,89.63 58.6,89.65 58.59,89.66 58.21,90.04 58.2,90.06 58.2,90.09 58.21,90.11 58.23,90.12
DGND on L03_SIG01 (solid shape): 1.56,78.57 2.94,77.19 2.95,77.17 2.95,77.15 2.95,72.34 2.95,72.32 2.94,72.3 2.16,71.53 2.15,71.51 2.14,71.46 2.12,71.44 2.03,71.39 2.01,71.39 1.99,71.4 1.9,71.44 1.8,71.44 1.76,71.45 1.7,71.51 1.69,71.52 1.68,71.54 1.68,72.08 1.69,72.1 1.7,72.11 2.39,72.81 2.4,72.82 2.41,72.84 2.41,76.5 2.43,76.53 2.45,76.53 2.66,77.04 2.11,77.03 2.1,77.02 2.08,77.01 1.99,77 1.97,77 1.95,77.02 1.5,77.47 1.49,77.48 1.49,77.5 1.49,78.52 1.49,78.55 1.52,78.57 1.53,78.57
DGND on L03_SIG01 (solid shape): 56.87,88.1 56.9,88.09 56.92,88.07 56.96,87.97 56.96,87.95 56.95,87.93 57.21,87.4 57.47,87.93 57.46,87.95 57.45,87.97 57.5,88.07 57.52,88.09 57.55,88.1 57.63,88.1 57.65,88.1 57.66,88.08 59.36,86.39 59.37,86.36 59.37,86.33 59.33,86.23 59.31,86.21 59.29,86.21 59.12,86.16 59,86.02 59,86.01 58.98,86 58.88,85.98 58.86,85.98 58.84,85.99 57.63,87.2 57.62,87.21 57.6,87.22 56.51,87.22 56.49,87.22 56.48,87.23 55.69,88.01 55.68,88.04 55.68,88.07 55.69,88.08 55.71,88.1
DGND on L03_SIG01 (solid shape): 32.95,114.87 32.97,114.86 32.99,114.85 33.42,114.41 33.44,114.4 33.46,114.4 36.53,114.4 36.55,114.4 36.57,114.38 36.66,114.29 36.68,114.27 36.67,114.24 36.67,114.22 36.64,114.21 36.58,114.21 36.56,114.2 36.54,114.19 35.91,113.56 35.89,113.55 35.87,113.54 35.78,113.55 35.76,113.57 35.76,113.57 35.32,113.68 35.18,113.26 35.18,113.25 35.18,113.23 35.12,113.15 35.11,113.13 35.08,113.12 32.32,113.12 32.29,113.13 32.27,113.16 32.24,113.26 32.24,113.29 32.26,113.3 32.6,113.98 32.32,114.69 32.31,114.7 32.31,114.73 32.35,114.83 32.37,114.86 32.39,114.87
DGND on L03_SIG01 (solid shape): 43.41,94.7 43.43,94.7 43.45,94.68 43.5,94.63 43.51,94.6 43.74,94.29 44.1,94.4 44.11,94.41 44.13,94.42 44.22,94.42 44.24,94.42 44.26,94.41 44.36,94.3 44.37,94.28 44.38,94.26 44.36,94.17 44.35,94.15 44.34,94.14 43.87,93.59 43.93,92.87 43.93,92.84 43.91,92.81 43.9,92.8 43.87,92.79 43.84,92.8 43.78,92.86 43.76,92.87 43.74,92.88 43.02,92.88 43,92.89 42.98,92.91 42.97,92.92 42.98,92.95 43.36,93.33 43.37,93.35 43.37,93.37 43.37,94.12 43.37,94.14 43.36,94.15 42.9,94.61 42.88,94.64 42.89,94.67 42.89,94.68 42.92,94.7
DGND on L03_SIG01 (solid shape): outline of 82 points within 25.96,65.25 27.92,70.22
DGND on L03_SIG01 (solid shape): 30.74,112.74 30.77,112.76 30.79,112.76 30.81,112.75 30.83,112.72 30.83,111.8 30.82,111.79 30.81,111.77 30.78,111.74 30.76,111.72 30.73,111.72 30.63,111.74 30.62,111.76 30.61,111.77 30.21,111.98 29.98,111.6 29.98,111.59 29.97,111.57 29.91,111.5 29.9,111.48 29.88,111.48 29.8,111.48 29.7,111.46 29.62,111.4 29.5,111.29 29.45,111.2 29.43,111.11 29.43,110.96 29.41,110.92 29.38,110.9 29.22,110.9 29.13,110.89 29.04,110.83 28.98,110.77 28.95,110.75 28.93,110.76 28.91,110.76 28.89,110.79 28.89,110.88 28.9,110.9 28.91,110.91 29.14,111.14 29.15,111.16 29.15,111.18 29.15,111.43 29.16,111.43 29.41,111.43 29.43,111.44 29.44,111.45 29.71,111.72 29.72,111.73 29.73,111.75 29.73,112.01 29.73,112.01 29.98,112.01 30,112.01 30.02,112.02
DGND on L03_SIG01 (solid shape): 18.84,102.69 18.87,102.68 18.88,102.66 18.89,102.64 18.88,102.61 18.71,102.44 18.69,102.43 18.67,102.42 18.59,102.42 18.57,102.43 18.03,102.25 18.47,101.88 18.48,101.88 18.5,101.88 18.58,101.82 18.6,101.8 18.6,101.78 18.6,101.41 18.6,101.39 18.59,101.37 17.69,100.47 17.68,100.46 17.67,100.43 17.66,100.41 17.58,100.34 17.55,100.34 17.47,100.36 17.39,100.35 17.37,100.36 17.3,100.42 17.29,100.44 17.28,100.46 17.28,101.46 17.28,101.47 17.27,101.49 16.4,102.36 16.39,102.37 16.37,102.37 14.96,102.37 14.94,102.37 14.93,102.36 14.56,101.99 14.5,101.98 14.45,101.97 14.43,101.98 14.42,101.99 14.41,102.03 14.42,102.06 15.03,102.68 15.05,102.69 15.07,102.69
