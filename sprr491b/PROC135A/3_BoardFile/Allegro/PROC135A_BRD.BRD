# Allegro board PROC135A_BRD.BRD (continued)
## Copper pours and planes (outline as drawn) (continued)
DGND on L10_SIG03 (solid shape): 59.97,39.75 60,39.74 60.02,39.71 60.02,39.7 60.02,39.67 59.22,38.88 59.21,38.87 59.19,38.86 58.1,38.86 58.08,38.86 58.06,38.85 57.54,38.33 57.53,38.32 57.51,38.32 57.46,38.32 57.43,38.33 57.41,38.35 57.4,38.37 57.4,38.4 57.41,38.42 57.46,38.67 57.33,38.89 57.32,38.89 57.31,38.91 57.31,39 57.31,39.02 57.32,39.04 57.34,39.06 57.36,39.07 57.38,39.08 58.16,39.08 58.18,39.08 58.19,39.09 58.83,39.73 58.85,39.74 58.87,39.75
DGND on L10_SIG03 (solid shape): 53.28,38.22 53.3,38.22 53.32,38.21 54.11,37.42 54.12,37.41 54.14,37.4 54.69,37.4 54.71,37.4 54.73,37.39 54.78,37.32 54.79,37.27 54.77,37.25 54.67,37.21 54.64,37.21 54.62,37.22 54.59,37.25 54.57,37.26 54.55,37.26 52.41,37.26 52.39,37.26 52.38,37.28 52.03,37.63 52.01,37.64 51.99,37.64 51.92,37.64 51.88,37.66 51.87,37.69 51.87,37.71 51.89,37.74 51.9,37.74 52.1,37.88 52.15,38.11 52.15,38.14 52.21,38.2 52.23,38.22 52.25,38.22
DGND on L10_SIG03 (solid shape): 13.96,105.57 15.64,103.89 15.65,103.88 15.67,103.87 19.58,103.87 19.6,103.87 19.62,103.86 19.83,103.65 19.84,103.62 19.84,103.59 19.83,103.58 19.81,103.56 19.59,103.56 19.57,103.56 19.55,103.54 19.47,103.46 19.45,103.45 19.43,103.45 15.05,103.45 15.04,103.45 15.02,103.46 13.5,104.98 13.49,105 13.49,105.04 13.5,105.06 13.56,105.09 13.59,105.13 13.66,105.34 13.84,105.47 13.89,105.53 13.9,105.56 13.93,105.57
DGND on L10_SIG03 (solid shape): 41.14,104.93 41.21,104.87 41.22,104.86 41.23,104.83 41.23,103.82 41.23,103.8 41.24,103.78 41.97,103.05 41.99,103.04 42.01,103.04 42.25,103.04 42.27,103.03 42.29,103.02 42.35,102.95 42.36,102.93 42.35,102.87 42.35,102.8 42.29,102.74 42.27,102.72 42.25,102.72 41.51,102.72 41.49,102.72 41.47,102.74 41.41,102.8 41.41,102.83 41.31,103.1 41.05,103.19 41.02,103.2 40.95,103.26 40.94,103.27 40.93,103.3 40.93,104.83 40.94,104.86 40.95,104.87 41.02,104.93 41.08,104.93
DGND on L10_SIG03 (solid shape): 33.76,131.61 33.78,131.6 33.8,131.58 33.85,131.48 33.84,131.45 33.83,131.44 33.57,130.7 33.9,129.98 33.91,129.97 33.91,129.94 33.87,129.84 33.85,129.82 33.83,129.81 30.35,129.81 30.32,129.82 30.3,129.84 30.26,129.94 30.27,129.97 30.28,129.98 30.6,130.7 30.34,131.44 30.33,131.45 30.33,131.48 30.37,131.58 30.39,131.6 30.42,131.61
DGND on L10_SIG03 (solid shape): 40.28,104.13 40.34,104.13 40.41,104.07 40.42,104.06 40.43,104.03 40.43,102.61 40.43,102.6 40.44,102.58 40.79,102.23 40.81,102.21 40.83,102.21 41.45,102.21 41.47,102.21 41.49,102.19 41.55,102.13 41.55,102.07 41.55,102 41.49,101.94 41.47,101.92 41.45,101.92 40.71,101.92 40.69,101.92 40.67,101.94 40.61,102 40.61,102.03 40.51,102.3 40.24,102.39 40.21,102.4 40.14,102.46 40.13,102.47 40.12,102.49 40.12,104.04 40.13,104.06 40.14,104.07 40.21,104.13
DGND on L10_SIG03 (solid shape): 4.51,107.47 4.54,107.48 4.57,107.48 4.58,107.47 4.6,107.45 4.6,106.34 4.6,106.32 4.58,106.3 3.02,104.74 3.01,104.72 3.01,104.7 3.01,104.05 3,104.03 2.99,104.01 1.87,102.88 1.84,102.87 1.81,102.87 1.8,102.88 1.78,102.91 1.78,104.71 1.79,104.73 1.8,104.75 3.15,106.1 3.17,106.11 3.19,106.12 3.28,106.11 3.3,106.09 3.31,106.08 3.82,106.03 3.76,106.54 3.75,106.55 3.74,106.57 3.73,106.66 3.73,106.68 3.74,106.7
DGND on L10_SIG03 (solid shape): 22.27,120.69 22.33,120.63 22.34,120.61 22.35,120.59 22.35,120.24 22.34,120.22 22.33,120.2 21.84,119.71 21.83,119.69 21.82,119.67 21.82,113.54 21.82,113.52 21.81,113.5 21.57,113.27 21.56,113.25 21.56,113.23 21.56,113.17 21.55,113.14 21.53,113.12 21.44,113.08 21.41,113.08 21.4,113.09 21.29,113.14 21.18,113.16 21.15,113.16 21.08,113.22 21.07,113.24 21.07,113.26 21.07,113.29 21.07,113.31 21.08,113.33 21.28,113.53 21.3,113.55 21.3,113.57 21.3,119.35 21.3,119.37 21.31,119.39 22.05,120.12 22.06,120.14 22.06,120.16 22.06,120.59 22.07,120.61 22.08,120.63 22.14,120.68
DGND on L10_SIG03 (solid shape): 46.99,137.05 47.01,137.06 47.04,137.06 47.06,137.05 47.07,137.03 47.07,135.99 47.07,135.97 47.06,135.96 46.67,135.57 46.65,135.56 46.63,135.56 46.53,135.57 46.51,135.59 46.51,135.6 45.98,135.69 46.07,135.16 46.08,135.15 46.09,135.13 46.11,135.04 46.11,135.02 46.1,134.99 44.84,133.74 44.81,133.73 44.79,133.73 44.77,133.74 44.75,133.76 44.75,135.27 44.76,135.29 44.77,135.31 45.14,135.68 45.15,135.69 45.17,135.69 45.61,135.69 45.63,135.7 45.65,135.71
DGND on L10_SIG03 (solid shape): 29.16,100.97 29.19,100.96 29.21,100.94 29.21,100.93 29.21,100.9 28.32,100.01 28.31,99.99 28.3,99.97 28.3,99.93 28.3,99.9 28.28,99.89 28.21,99.83 28.19,99.83 28.14,99.83 28.1,99.84 27.18,99.84 27.16,99.83 27.15,99.82 25.67,98.34 25.66,98.33 25.65,98.31 25.65,97.99 25.64,97.96 25.62,97.94 25.52,97.9 25.49,97.9 25.48,97.91 25.39,97.97 25.27,97.99 25.24,98.01 25.22,98.05 25.24,98.08 25.27,98.12 25.29,98.13 25.29,98.15 25.29,99.24 25.29,99.26 25.3,99.28 25.98,99.95 26,99.96 26.02,99.97 26.91,99.97 26.93,99.97 26.94,99.98 27.92,100.96 27.94,100.97 27.96,100.97
DGND on L10_SIG03 (solid shape): 84.31,107.19 84.35,107.18 84.36,107.14 84.36,104.78 84.36,104.77 84.35,104.75 84.33,104.73 84.31,104.72 84.29,104.71 79.86,104.71 79.83,104.72 79.81,104.74 79.81,104.76 79.81,104.79 80.82,105.8 80.84,105.8 81.03,106.36 80.47,106.18 80.46,106.15 79.41,105.1 79.39,105.09 79.37,105.09 77.97,105.09 77.93,105.1 77.92,105.14 77.92,107.14 77.93,107.18 77.97,107.19
DGND on L10_SIG03 (solid shape): 33.43,115.61 33.44,115.61 33.46,115.6 33.62,115.44 33.63,115.43 33.65,115.43 33.98,115.43 34,115.42 34.02,115.41 34.07,115.35 34.08,115.32 34.15,115.08 34.36,114.96 34.39,114.95 35.45,113.88 35.46,113.86 35.46,113.83 35.44,113.74 35.42,113.72 35.4,113.71 35.24,113.62 35.16,113.45 35.15,113.44 35.13,113.42 35.03,113.39 35.01,113.39 34.98,113.4 32.92,115.47 32.9,115.5 32.92,115.54 32.93,115.55 32.95,115.56 33,115.55 33.03,115.55 33.2,115.55 33.29,115.56 33.38,115.61
DGND on L10_SIG03 (solid shape): 39.56,37.98 39.63,37.93 39.65,37.91 39.65,37.89 39.65,37.21 39.65,37.19 39.64,37.17 38.91,36.44 38.89,36.43 38.86,36.43 38.77,36.44 38.75,36.45 38.75,36.46 38.35,36.59 38.14,36.23 38.15,36.21 38.14,36.19 38.08,36.13 38.06,36.11 38.04,36.11 37.63,36.11 37.6,36.11 37.59,36.13 37.53,36.19 37.52,36.21 37.53,36.28 37.52,36.35 37.53,36.37 37.59,36.44 37.6,36.45 37.63,36.46 37.78,36.46 37.8,36.46 37.82,36.47 39.23,37.88 39.24,37.91 39.33,37.98 39.35,37.99 39.36,37.98 39.44,37.97 39.52,37.99 39.54,37.99
DGND on L10_SIG03 (solid shape): 41.66,129.3 41.69,129.29 41.7,129.26 41.74,129.15 41.72,129.12 41.71,129.11 41.21,128.37 41.45,127.51 41.46,127.5 41.46,127.47 41.42,127.37 41.4,127.35 41.37,127.34 38.41,127.34 38.39,127.35 38.37,127.36 38.29,127.44 38.21,127.65 38.17,127.87 38.17,127.89 38.15,128.58 37.71,129.11 37.69,129.12 37.68,129.15 37.71,129.26 37.73,129.29 37.76,129.3
DGND on L10_SIG03 (solid shape): 48.24,102.22 48.96,102.22 48.98,102.21 49,102.2 49.06,102.13 49.06,102.1 49.1,101.91 49.24,101.77 49.25,101.76 49.27,101.74 49.27,101.55 49.27,101.53 49.28,101.52 49.44,101.36 49.46,101.33 49.46,101.31 49.43,101.21 49.41,101.19 49.39,101.19 49.14,100.92 49.28,100.59 49.29,100.58 49.31,100.56 49.31,100.55 49.29,100.51 49.26,100.5 49.2,100.5 49.18,100.5 49.17,100.51 48.35,101.32 48.34,101.34 48.34,101.36 48.34,101.68 48.34,101.7 48.32,101.72 48.18,101.86 48.17,101.88 48.16,101.9 48.16,102.17 48.17,102.2 48.19,102.22 48.21,102.22
DGND on L10_SIG03 (solid shape): 14.3,109.49 14.36,109.48 14.43,109.43 14.44,109.41 14.44,109.39 14.44,109.12 14.45,109.1 14.46,109.08 16.11,107.43 16.12,107.42 16.14,107.42 16.98,107.42 16.99,107.41 17.01,107.4 17.16,107.26 17.17,107.24 17.17,107.22 17.17,107.13 17.15,107.11 17.12,106.61 17.61,106.64 17.64,106.66 17.72,106.67 17.74,106.66 17.76,106.65 18.62,105.79 18.63,105.77 18.63,105.74 18.62,105.72 18.6,105.71 17.47,105.71 17.45,105.71 17.43,105.72 14.17,108.99 14.15,109 14.15,109.02 14.15,109.39 14.16,109.41 14.17,109.43 14.23,109.48
DGND on L10_SIG03 (solid shape): 43.05,95.78 43.07,95.78 43.08,95.76 43.14,95.7 43.15,95.67 43.24,95.44 43.47,95.33 43.5,95.33 43.56,95.27 43.57,95.25 43.57,95.23 43.57,95.2 43.58,95.18 43.59,95.17 43.71,95.05 43.72,95.03 43.72,95.01 43.71,94.91 43.69,94.89 43.68,94.89 43.54,94.72 43.53,94.5 43.53,94.49 43.53,94.47 43.47,94.39 43.45,94.37 43.43,94.37 42.93,94.37 42.91,94.37 42.87,94.41 42.87,94.43 42.87,95.14 42.87,95.16 42.86,95.18 42.5,95.53 42.49,95.54 42.47,95.54 42.31,95.54 42.29,95.55 42.28,95.56 42.22,95.62 42.22,95.7 42.28,95.76 42.29,95.78 42.31,95.78
DGND on L10_SIG03 (solid shape): 61.83,35.3 61.86,35.31 61.89,35.31 61.9,35.3 61.92,35.27 61.92,34.45 61.91,34.43 61.9,34.41 61.35,33.85 61.33,33.84 61.31,33.84 59.32,33.84 59.3,33.84 59.28,33.86 59.22,33.93 59.22,33.95 59.22,33.96 59.18,34.19 58.99,34.33 58.98,34.34 58.96,34.36 58.96,34.4 58.99,34.43 59.02,34.44 59.16,34.58 59.18,34.6 59.2,34.6 60.76,34.6 60.78,34.59 60.79,34.58 60.85,34.51 60.86,34.49 60.86,34.48 61.3,34.11 61.38,34.68 61.37,34.69 61.36,34.71 61.36,34.8 61.36,34.82 61.37,34.84
DGND on L10_SIG03 (solid shape): 30.77,41.16 30.79,41.18 30.82,41.18 30.92,41.14 30.94,41.12 30.94,41.1 31.14,40.83 31.47,40.87 31.5,40.88 32.89,40.88 32.92,40.87 32.94,40.85 32.95,40.83 32.94,40.8 31.75,39.62 31.73,39.61 31.52,39.49 31.45,39.26 31.44,39.23 31.38,39.17 31.37,39.16 31.35,39.16 30.4,39.16 30.38,39.16 30.36,39.17 29.66,39.87 29.65,39.88 29.63,39.89 26.44,39.89 26.42,39.89 26.41,39.9 26.26,40.04 26.25,40.06 26.23,40.06 26.18,40.06 26.15,40.07 26.13,40.09 26.12,40.11 26.13,40.14 26.61,40.62 26.63,40.63 26.65,40.63 30.22,40.63 30.24,40.64 30.25,40.65
DGND on L10_SIG03 (solid shape): 39.41,97.27 39.43,97.26 39.45,97.23 39.45,97.01 39.46,96.99 39.47,96.97 39.52,96.92 39.53,96.9 39.53,96.87 39.52,96.85 39.5,96.84 39.21,96.84 39.19,96.83 39.17,96.82 38.85,96.5 38.84,96.49 38.83,96.47 38.83,95.23 38.84,95.21 38.85,95.2 39.08,94.97 39.09,94.95 39.09,94.93 39.09,94.83 39.08,94.8 39.06,94.78 39.05,94.77 39.02,94.78 38.85,94.94 38.84,94.95 38.82,94.96 38.74,94.96 38.7,94.97 38.69,95.01 38.69,95.26 38.69,95.28 38.67,95.29 38.6,95.37 38.59,95.39 38.59,95.4 38.59,95.5 38.58,95.55 38.57,95.6 38.57,96.83 38.57,96.85 38.58,96.87 38.64,96.93 38.67,96.93 38.86,96.99 38.98,97.13 38.99,97.14 39.1,97.25 39.12,97.26 39.14,97.27
DGND on L10_SIG03 (solid shape): 50.86,38.53 50.88,38.52 50.89,38.51 51.17,38.24 51.19,38.23 51.2,38.22 51.39,38.22 51.41,38.22 51.43,38.2 51.49,38.14 51.49,38.11 51.51,37.95 51.6,37.82 51.61,37.81 51.62,37.78 51.58,37.67 51.56,37.65 51.53,37.64 50.78,37.64 50.76,37.64 50.75,37.63 50.47,37.35 50.45,37.34 50.43,37.33 47.69,37.33 47.67,37.34 47.66,37.35 46.89,38.11 46.88,38.14 46.88,38.17 46.89,38.18 46.91,38.2 47.83,38.2 47.85,38.2 47.86,38.19 47.92,38.13 47.93,38.11 48.39,37.83 48.5,38.36 48.49,38.37 48.49,38.4 48.53,38.5 48.55,38.52 48.58,38.53
DGND on L10_SIG03 (solid shape): 28.9,22.09 28.92,22.08 28.94,22.07 29.65,21.37 29.66,21.35 29.68,21.35 32.36,21.35 32.38,21.35 32.4,21.34 32.71,21.03 32.72,21.01 32.72,20.98 32.71,20.89 32.69,20.87 32.68,20.86 32.54,20.73 32.49,20.54 32.49,20.53 32.47,20.5 32.37,20.46 32.34,20.45 32.32,20.47 31.78,21.01 31.76,21.02 31.74,21.02 27.93,21.02 27.91,21.04 27.9,21.05 27.6,21.23 27.31,21.05 27.3,21.04 27.28,21.02 26.19,21.02 26.16,21.03 26.15,21.05 26.09,21.13 26.1,21.16 26.1,21.17 26.15,21.32 26.13,21.47 26.12,21.48 26.12,21.5 26.18,21.58 26.2,21.6 26.22,21.61 26.76,21.61 26.78,21.61 26.8,21.62 27.25,22.07 27.27,22.08 27.29,22.09
DGND on L10_SIG03 (solid shape): 51.23,53.99 51.26,53.98 51.28,53.96 51.29,53.94 51.28,53.91 51.07,53.7 51.05,53.69 51.03,53.68 50.15,53.68 50.13,53.68 50.11,53.67 49.68,53.23 49.66,53.22 49.63,53.22 49.54,53.23 49.53,53.24 49.52,53.25 49.01,53.3 49.06,52.79 49.07,52.78 49.08,52.76 49.09,52.67 49.09,52.65 49.08,52.63 48.99,52.55 48.98,52.54 48.96,52.53 48.28,52.53 48.25,52.54 48.23,52.56 48.18,52.64 48.18,52.67 48.19,52.68 48.22,52.89 48.12,53.08 48.11,53.09 48.1,53.12 48.14,53.22 48.16,53.24 48.19,53.25 48.23,53.25 48.25,53.26 48.26,53.27 48.97,53.97 48.99,53.98 49,53.99
DGND on L10_SIG03 (solid shape): 4.07,104.36 4.1,104.34 4.12,104.31 4.12,104.07 4.12,104.05 4.13,104.03 4.58,103.58 4.6,103.56 4.6,103.54 4.6,94.95 4.6,94.94 4.58,94.92 2.71,93.04 2.68,93.03 2.65,93.03 2.64,93.03 2.62,93.06 2.62,93.36 2.62,93.38 2.63,93.4 3.07,93.84 3.08,93.85 3.09,93.87 3.09,95.14 3.09,95.17 3.1,95.18 3.18,95.24 3.2,95.25 3.21,95.24 3.62,95.56 3.21,95.89 3.2,95.88 3.18,95.89 3.1,95.95 3.09,95.96 3.09,95.99 3.09,102.89 3.09,102.91 3.1,102.93 3.93,103.75 3.94,103.77 3.94,103.79 3.94,104.1 4,104.22 4.02,104.31 4.02,104.33 4.05,104.36
DGND on L10_SIG03 (solid shape): 7.44,127.03 7.47,127.03 7.49,127.01 9.1,125.4 9.11,125.39 9.12,125.37 9.12,123.38 9.11,123.36 9.1,123.34 8.88,123.12 8.85,123.1 8.82,123.11 8.72,123.15 8.71,123.18 8.71,123.19 8,124.33 6.68,124.12 6.66,124.11 6.64,124.1 6.54,124.15 6.51,124.17 6.51,124.19 6.51,126.78 6.51,126.8 6.53,126.83 6.55,126.85 6.58,126.85 6.67,126.83 6.69,126.82 6.69,126.81 7.06,126.64 7.32,126.95 7.32,126.96 7.34,126.99
DGND on L10_SIG03 (solid shape): 40.59,140.48 40.62,140.47 40.64,140.45 40.68,140.35 40.68,140.32 40.67,140.31 40.91,139.75 41.16,140.31 41.15,140.32 41.14,140.35 41.19,140.45 41.21,140.47 41.23,140.48 41.51,140.48 41.54,140.47 41.56,140.44 41.6,140.34 41.59,140.31 41.58,140.3 41.47,140 41.66,139.74 41.67,139.74 41.69,139.72 41.7,139.62 41.7,139.6 41.69,139.58 41.13,139.02 41.11,139.01 41.09,139 38.97,139 38.94,139.01 38.92,139.04 38.91,139.05 38.92,139.08 40.3,140.46 40.32,140.47 40.34,140.48
DGND on L10_SIG03 (solid shape): 33.34,87.46 33.36,87.46 33.38,87.45 33.55,87.34 33.75,87.36 33.76,87.36 33.79,87.36 34.1,87.05 34.12,87.04 34.14,87.03 34.47,87.03 34.49,87.03 34.52,86.99 34.53,86.97 34.53,86.37 34.53,86.35 34.54,86.33 34.63,86.24 34.65,86.21 34.63,86.17 34.62,86.16 34.59,86.16 34.52,86.17 34.44,86.18 34.37,86.24 34.36,86.25 34.36,86.27 34.36,86.5 34.36,86.52 34.34,86.54 33.96,86.92 33.94,86.93 33.92,86.94 33.32,86.94 33.3,86.96 33.29,86.97 33.14,87.16 32.9,87.19 32.89,87.18 32.86,87.19 32.85,87.2 32.84,87.24 32.85,87.27 32.92,87.33 32.94,87.34 32.95,87.34 33.1,87.36 33.23,87.45 33.25,87.46 33.27,87.46
DGND on L10_SIG03 (solid shape): 47.21,88.86 47.23,88.87 47.26,88.87 47.28,88.86 47.29,88.84 47.29,88.02 47.29,88 47.28,87.99 47.25,87.95 47.23,87.94 47.21,87.94 46.76,87.94 46.74,87.93 46.73,87.92 46.48,87.67 46.45,87.66 46.43,87.66 46.33,87.69 46.31,87.71 46.31,87.73 46.07,87.98 45.73,87.88 45.71,87.87 45.69,87.87 45.62,87.87 45.6,87.87 45.55,87.94 45.56,87.98 45.69,88.1 45.7,88.12 45.7,88.14 45.72,88.17 45.75,88.19 45.78,88.19 45.8,88.18 46.15,88.18 46.31,88.48 46.32,88.51 46.38,88.57 46.39,88.59 46.41,88.59 46.92,88.59 46.94,88.59 46.95,88.6
DGND on L10_SIG03 (solid shape): 63.76,21.41 63.79,21.4 64.17,21.02 64.17,21.02 64.25,20.93 64.25,20.91 64.24,20.87 64.24,20.82 64.24,20.76 64.25,20.72 64.24,20.7 64.18,20.62 64.16,20.61 63.96,20.61 63.92,20.6 63.51,20.19 63.47,20.17 60.92,20.17 60.82,20.25 60.82,20.27 60.82,20.31 60.82,20.37 60.81,20.4 60.82,20.43 61.19,20.64 61.58,20.64 61.58,20.58 61.59,20.53 61.61,20.48 61.63,20.44 61.66,20.39 61.7,20.36 61.74,20.33 61.79,20.3 61.84,20.29 61.89,20.28 61.94,20.28 61.99,20.29 62.04,20.3 62.09,20.33 62.13,20.36 62.17,20.39 62.2,20.44 62.22,20.48 62.24,20.53 62.24,20.58 62.24,20.64 62.24,20.69 62.22,20.74 62.2,20.78 62.17,20.82 62.13,20.86 62.09,20.89 62.04,20.92 61.99,20.93 61.94,20.94 61.89,20.94 61.84,20.93 61.79,20.92 61.74,20.89 61.7,20.86 61.66,20.82 61.63,20.78 61.61,20.74 61.59,20.69 61.58,20.64 61.19,20.64 61.95,21.4 61.99,21.41
DGND on L10_SIG03 (solid shape): 33.43,111.69 33.46,111.7 33.5,111.69 33.54,111.64 33.55,111.62 33.68,111.4 33.91,111.34 33.95,111.33 34.01,111.27 34.02,111.26 34.03,111.23 34.01,111.2 33.96,111.19 33.61,111.05 33.61,110.67 33.63,110.65 33.62,110.62 33.61,110.6 33.57,110.59 33.54,110.6 33.44,110.7 33.42,110.72 33.4,110.72 33.02,110.72 33,110.72 32.99,110.73 32.95,110.77 32.94,110.79 32.94,110.81 32.94,111.18 32.93,111.2 32.92,111.22 32.81,111.32 32.8,111.36 32.81,111.4 32.83,111.41 32.87,111.41 32.88,111.4 33.22,111.37 33.41,111.65
DGND on L10_SIG03 (solid shape): 37.11,97.46 37.13,97.48 37.16,97.48 37.18,97.47 37.19,97.44 37.19,96.1 37.19,96.08 37.18,96.06 37.12,96 37.09,96 36.9,95.95 36.78,95.8 36.77,95.79 36.5,95.51 36.48,95.5 36.46,95.5 36.11,95.5 36.09,95.49 36.08,95.48 35.72,95.13 35.69,95.13 35.67,95.14 35.51,95.19 35.35,95.17 35.31,95.16 35.29,95.18 35.28,95.19 35.27,95.23 35.28,95.26 35.36,95.34 35.39,95.35 35.4,95.34 35.72,95.44 35.79,95.77 35.79,95.78 35.8,95.81 36.13,96.15 36.16,96.16 36.18,96.15 36.5,96.22 36.6,96.54 36.6,96.55 36.61,96.58 36.95,96.93 36.96,96.94 36.97,96.96 36.97,97.3 36.97,97.32 36.98,97.34
DGND on L10_SIG03 (solid shape): 31.22,46.44 31.25,46.45 31.28,46.45 31.38,46.41 31.4,46.38 31.4,46.37 31.41,46.27 31.45,46.18 31.46,46.16 31.46,46.14 31.41,46.05 31.39,46.03 31.37,46.02 31.19,46.02 31.17,46.01 31.15,46 29.46,44.31 29.45,44.29 29.44,44.27 29.44,44.07 29.44,44.05 29.43,44.04 29.24,43.85 29.23,43.84 29.21,43.83 26.87,43.83 26.85,43.83 26.83,43.82 26.78,43.77 26.75,43.75 26.71,43.77 26.7,43.78 26.69,43.8 26.7,43.81 26.63,44.05 26.41,44.18 26.37,44.22 26.37,44.25 26.4,44.35 26.42,44.37 26.44,44.37 26.7,44.7 26.41,45.02 26.38,45.04 26.37,45.06 26.37,45.09 26.38,45.11 26.4,45.12 29.88,45.12 29.9,45.13 29.92,45.14
DGND on L10_SIG03 (solid shape): 40.93,87.46 40.95,87.47 40.97,87.47 41.06,87.47 41.08,87.45 41.09,87.44 41.4,87.26 41.73,87.39 41.76,87.41 41.85,87.42 41.9,87.39 41.91,87.36 41.91,87.25 41.9,87.23 41.88,87.22 41.67,86.89 41.84,86.54 41.85,86.53 41.86,86.51 41.86,86.42 41.86,86.4 41.85,86.38 41.67,86.2 41.66,86.19 41.65,86.17 41.65,85.88 41.65,85.86 41.62,85.84 41.27,85.84 41.25,85.84 41.23,85.86 41.18,85.93 41.17,85.95 41.17,85.96 41.17,86.2 41.03,86.38 41.02,86.4 41.01,86.43 41.01,86.5 41.02,86.53 41.03,86.54 41.18,86.93 40.92,87.25 40.91,87.25 40.89,87.27 40.87,87.37 40.87,87.39 40.89,87.41
DGND on L10_SIG03 (solid shape): 50.47,40.45 50.49,40.47 50.52,40.47 50.61,40.45 50.63,40.44 50.68,40.35 50.68,39.95 50.66,39.92 50.62,39.9 48.54,39.9 48.52,39.9 48.51,39.89 47.6,38.98 47.59,38.97 47.54,38.97 47.51,38.98 47.49,39.02 47.49,39.03 47.5,39.05 47.51,39.06 47.37,39.65 47.06,39.13 47.07,39.12 47.07,39.09 47.02,38.99 47,38.97 46.98,38.97 46.35,38.97 46.33,38.97 46.31,38.99 46.26,39.08 46.26,39.11 46.26,39.12 46.27,39.43 46.02,39.61 46,39.62 45.43,40.19 45.42,40.21 45.42,40.24 45.43,40.26 45.45,40.27 50.27,40.27 50.29,40.28 50.31,40.29
DGND on L10_SIG03 (solid shape): 25.74,89.78 25.82,89.77 25.89,89.72 25.9,89.7 25.9,89.68 25.9,84.1 25.9,84.08 25.89,84.06 24.83,83 24.8,82.99 24.77,82.99 24.76,82.99 24.74,83.02 24.74,86.39 24.74,86.41 24.75,86.43 24.88,86.55 24.9,86.57 24.92,86.57 25.01,86.56 25.03,86.54 25.07,86.49 25.1,86.45 25.11,86.44 25.12,86.42 25.12,86.34 25.11,86.32 25.1,86.3 25.33,85.73 25.55,86.3 25.54,86.32 25.53,86.34 25.53,86.42 25.54,86.44 25.55,86.45 25.65,86.73 25.49,86.98 25.48,86.99 25.47,87.01 25.45,87.1 25.46,87.12 25.47,87.14 25.54,87.22 25.55,87.24 25.56,87.25 25.56,89.69 25.56,89.71 25.58,89.73 25.65,89.78 25.67,89.79
DGND on L10_SIG03 (solid shape): 57.81,57.99 57.84,57.98 57.85,57.96 57.9,57.86 57.89,57.83 57.88,57.82 57.64,57.34 57.67,56.81 57.67,56.79 57.63,56.57 57.55,56.36 57.54,56.35 57.27,56.08 57.26,56.06 57.26,56.04 57.26,53.18 57.25,53.16 57.24,53.14 54.88,50.78 54.86,50.77 54.84,50.76 53.29,50.76 53.26,50.77 53.25,50.79 53.24,50.81 53.25,50.84 55.18,52.78 55.19,52.79 55.2,52.81 55.2,55.8 55.2,55.82 55.21,55.84 55.36,55.99 55.38,56 55.58,56.08 55.8,56.12 55.82,56.12 57.02,56.55 56.93,57.82 56.92,57.83 56.91,57.86 56.96,57.96 56.98,57.98 57,57.99
DGND on L10_SIG03 (solid shape): 66.23,46.58 66.26,46.6 66.29,46.59 66.3,46.59 66.32,46.56 66.32,44.04 66.32,44.02 66.3,44 66.22,43.95 66.19,43.94 66.18,43.95 65.73,43.64 66.18,43.33 66.19,43.34 66.22,43.34 66.3,43.28 66.32,43.26 66.32,43.24 66.32,42.02 66.32,42 66.31,41.98 64.95,40.63 64.93,40.62 64.91,40.62 64.81,40.64 64.79,40.66 64.78,40.67 64.73,40.78 64.63,40.86 64.62,40.87 64.61,40.89 64.6,40.98 64.6,41 64.61,41.02 64.73,41.14 64.74,41.16 64.75,41.18 64.75,41.78 64.75,41.81 64.77,41.82 64.84,41.88 64.86,41.89 64.87,41.88 65.27,42.21 64.87,42.53 64.86,42.53 64.84,42.53 64.77,42.59 64.75,42.61 64.75,42.63 64.75,45.07 64.75,45.09 64.76,45.11
DGND on L10_SIG03 (solid shape): outline of 84 points within 26.31,41.78 38.05,46.97
DGND on L10_SIG03 (solid shape): 1.35,76.36 3.91,73.8 3.93,73.79 3.95,73.79 4.73,73.79 4.8,73.75 4.85,73.73 4.86,73.71 4.88,73.61 4.88,73.59 4.87,73.57 4.31,73 4.29,72.99 4.27,72.99 3.73,72.99 3.71,72.98 3.69,72.97 2.08,71.36 2.04,71.36 2.03,71.37 1.5,71.18 1.91,70.79 1.92,70.8 1.94,70.79 2.01,70.73 2.03,70.72 2.03,70.69 2.03,65.71 2.03,65.69 2.02,65.68 1.98,65.64 1.95,65.63 1.93,65.63 1.91,65.63 1.89,65.66 1.89,67.02 1.89,67.04 1.88,67.06 1.29,67.65 1.28,67.66 1.27,67.68 1.27,74.77 1.28,74.79 1.29,74.8 1.35,74.86 1.38,74.87 1.73,75.2 1.38,75.53 1.35,75.53 1.29,75.59 1.28,75.61 1.27,75.63 1.27,76.32 1.28,76.34 1.3,76.36 1.32,76.37
DGND on L10_SIG03 (solid shape): 39.48,42.8 39.5,42.79 39.52,42.78 39.57,42.71 39.58,42.68 39.57,42.67 39.57,42.51 39.65,42.37 39.65,42.36 39.66,42.34 39.66,42.31 39.65,42.29 39.64,42.27 39.25,41.88 39.23,41.86 39.21,41.86 39.18,41.86 39.16,41.86 39.15,41.87 38.67,41.83 38.73,41.36 38.74,41.35 38.75,41.33 38.75,41.29 38.75,41.27 38.72,41.24 38.67,41.23 38.65,41.22 37.38,39.95 37.37,39.93 37.37,39.91 37.37,39.83 37.36,39.81 37.35,39.8 36.21,38.66 36.19,38.64 36.18,38.64 36.12,38.64 36.1,38.65 36.08,38.67 36.07,38.69 36.08,38.72 36.75,39.39 36.76,39.41 36.76,39.43 36.76,40.58 36.77,40.6 36.78,40.62 38.53,42.37 38.55,42.39 38.57,42.39 38.66,42.39 38.68,42.37 39.09,42.3 39.25,42.67 39.25,42.68 39.25,42.71 39.31,42.78 39.33,42.79 39.35,42.8
DGND on L10_SIG03 (solid shape): 32.27,88.96 32.52,88.7 32.54,88.69 32.59,88.68 32.61,88.67 32.66,88.59 32.67,88.57 32.66,88.56 32.82,88.18 33.23,88.25 33.25,88.26 33.27,88.26 33.34,88.26 33.36,88.26 33.38,88.25 33.75,88.16 33.96,88.47 33.97,88.5 34.03,88.56 34.04,88.57 34.06,88.58 34.5,88.58 34.52,88.57 34.53,88.56 34.59,88.5 34.59,88.43 34.53,88.37 34.52,88.36 34.5,88.35 34.17,88.35 34.15,88.35 34.13,88.34 33.78,87.98 33.75,87.97 33.74,87.98 33.54,87.98 33.38,87.88 33.36,87.87 33.34,87.87 33.27,87.87 33.25,87.87 33.23,87.88 33.03,87.99 32.8,87.94 32.77,87.94 32.74,87.95 32.47,88.22 32.45,88.23 32.43,88.23 32.24,88.23 32.22,88.24 32.19,88.27 32.19,88.91 32.2,88.94 32.22,88.96 32.24,88.97
DGND on L10_SIG03 (solid shape): outline of 91 points within 27.15,34.02 32.4,35.88
DGND on L10_SIG03 (solid shape): 26.29,83.39 26.32,83.4 26.35,83.4 26.36,83.39 26.38,83.37 26.38,82.01 26.38,81.99 26.39,81.97 26.61,81.76 26.62,81.74 26.62,81.71 26.6,81.62 26.59,81.6 26.58,81.59 26.42,81.12 26.9,81.02 26.91,81.03 26.94,81.04 27.04,80.99 27.06,80.97 27.07,80.94 27.07,79.79 27.06,79.76 27.05,79.75 26.98,79.69 26.95,79.68 26.94,79.69 26.54,79.36 26.94,79.04 26.95,79.04 26.98,79.04 27.05,78.98 27.06,78.96 27.07,78.94 27.07,78.69 27.06,78.67 27.05,78.65 26.98,78.6 26.95,78.59 26.94,78.59 26.54,78.27 26.94,77.95 26.95,77.95 26.98,77.94 27.05,77.89 27.06,77.87 27.07,77.85 27.07,77.5 27.06,77.48 27.03,77.46 27.02,77.45 26.99,77.46 25.83,78.62 25.82,78.63 25.81,78.65 25.81,82.89 25.82,82.91 25.83,82.92
DGND on L10_SIG03 (solid shape): 45.09,140.97 45.12,140.96 45.13,140.94 45.18,140.85 45.18,140.82 45.18,140.81 45.46,140.3 45.74,140.81 45.73,140.82 45.73,140.85 45.78,140.94 45.8,140.96 45.82,140.97 47.5,140.97 47.52,140.96 47.54,140.95 48.02,140.47 48.03,140.44 48.08,140.32 48.17,140.22 48.17,140.21 48.19,140.2 48.19,140.11 48.19,140.09 48.18,140.07 47.95,139.84 47.94,139.83 47.92,139.83 46.56,139.83 46.53,139.83 46.51,139.85 46.46,139.94 46.46,139.97 46.47,139.98 46.19,140.48 45.91,139.98 45.91,139.97 45.91,139.94 45.86,139.85 45.84,139.83 45.82,139.83 44.81,139.83 44.79,139.83 44.77,139.85 44.72,139.92 44.71,139.94 44.72,139.95 44.66,140.24 44.4,140.37 44.38,140.37 44.36,140.38 44.32,140.48 44.32,140.51 44.33,140.54 44.74,140.95 44.76,140.96 44.78,140.97
DGND on L10_SIG03 (solid shape): 19.51,102.43 19.53,102.43 19.54,102.42 19.96,102 19.97,101.99 19.99,101.99 21,101.99 21.03,101.98 21.04,101.97 21.1,101.89 21.1,101.87 21.1,101.85 21.41,101.42 21.72,101.85 21.72,101.87 21.72,101.89 21.78,101.97 21.8,101.98 21.82,101.99 22.14,101.99 22.16,101.98 22.18,101.96 22.23,101.87 22.23,101.85 22.22,101.84 22.18,101.68 22.21,101.53 22.21,101.52 22.21,101.49 22.16,101.41 22.14,101.39 22.11,101.39 21.93,101.39 21.91,101.38 21.89,101.37 21.64,101.12 21.63,101.11 21.61,101.11 20.74,101.11 20.71,101.11 20.7,101.13 20.64,101.2 20.64,101.23 20.64,101.24 20.32,101.67 20.01,101.24 20.01,101.23 20.01,101.2 19.95,101.13 19.93,101.11 19.91,101.11 19.18,101.11 19.16,101.11 19.14,101.12 18.51,101.75 18.5,101.77 18.5,101.79 18.51,101.88 18.52,101.9 18.53,101.91 18.66,102.08 18.66,102.3 18.66,102.31 18.66,102.33 18.72,102.41 18.74,102.43 18.76,102.43
DGND on L10_SIG03 (solid shape): outline of 102 points within 24,45.77 30.98,49.43
DGND on L10_SIG03 (solid shape): 26.06,122.57 26.09,122.56 26.11,122.54 26.11,122.52 26.11,122.49 24.43,120.81 24.4,120.8 24.19,120.68 24.12,120.46 24.11,120.43 24.06,120.36 24.04,120.35 24.02,120.35 23.81,120.35 23.79,120.34 23.77,120.33 23.05,119.61 23.04,119.6 23.04,119.58 23.04,113.81 23.04,113.79 23.05,113.77 23.2,113.62 23.22,113.55 23.22,113.52 23.16,113.45 23.14,113.44 23.12,113.43 22.98,113.43 22.96,113.44 22.94,113.45 22.88,113.52 22.88,113.55 22.88,113.56 22.79,113.89 22.46,113.96 22.45,113.96 22.43,113.96 22.35,114.02 22.34,114.03 22.33,114.06 22.33,119.46 22.33,119.48 22.34,119.5 22.84,119.99 22.85,120.01 22.86,120.03 22.86,120.59 22.86,120.61 22.87,120.63 22.94,120.69 22.96,120.69 22.98,120.69 23.24,120.76 23.36,121.01 23.37,121.04 23.45,121.12 23.48,121.13 23.52,121.12 23.53,121.11 23.54,121.09 23.53,121.07 23.81,120.69 24.19,120.97 24.2,120.99 25.76,122.55 25.78,122.56 25.8,122.57
DGND on L10_SIG03 (solid shape): 32.31,45.72 32.34,45.73 32.37,45.73 32.38,45.72 32.4,45.7 32.4,45.05 32.4,45.03 32.39,45.02 31.86,44.5 31.84,44.48 31.81,44.49 31.71,44.53 31.69,44.56 31.69,44.57 31.13,44.83 31.38,44.26 31.4,44.26 31.42,44.25 31.47,44.15 31.47,44.12 31.46,44.09 31.11,43.74 31.09,43.73 31.07,43.73 31.03,43.74 31.02,43.78 31.02,43.79 30.65,44.23 30.45,43.7 30.46,43.68 30.46,43.63 30.46,43.62 30.44,43.6 30.13,43.29 30.11,43.27 30.09,43.27 29.86,43.27 29.85,43.27 29.83,43.26 29.48,42.91 29.47,42.9 29.45,42.9 26.75,42.9 26.72,42.9 26.7,42.93 26.7,42.94 26.7,42.97 27.04,43.31 27.06,43.32 27.08,43.33 29.42,43.33 29.44,43.33 29.45,43.34 29.94,43.83 29.95,43.84 29.95,43.86 29.95,44.06 29.96,44.08 29.97,44.1 31.36,45.49 31.38,45.51 31.4,45.51 32.09,45.51 32.11,45.51 32.12,45.52
DGND on L10_SIG03 (solid shape): outline of 107 points within 42.53,103.77 44.72,106.53
DGND on L10_SIG03 (solid shape): 28.02,124.43 28.05,124.42 28.07,124.41 28.12,124.32 28.12,124.29 28.11,124.28 28.4,123.79 28.69,124.28 28.68,124.29 28.68,124.32 28.73,124.41 28.75,124.42 28.78,124.43 30.05,124.43 30.07,124.43 30.09,124.42 30.3,124.2 30.32,124.19 30.34,124.19 31.13,124.19 31.16,124.18 31.18,124.15 31.19,124.14 31.18,124.11 29.83,122.76 29.81,122.75 29.78,122.75 29.68,122.79 29.66,122.82 29.66,122.83 29.27,123.15 29.02,122.7 29.03,122.69 29.02,122.67 28.97,122.59 28.95,122.57 28.93,122.57 27.91,122.57 27.89,122.57 27.87,122.59 27.82,122.67 27.81,122.69 27.82,122.7 27.71,123.09 27.31,123.09 27.28,123.08 26.96,123.08 26.93,123.09 26.91,123.11 26.9,123.12 26.91,123.15 27.56,123.81 27.59,123.82 27.83,123.99 27.84,124.29 27.83,124.3 27.83,124.32 27.89,124.41 27.9,124.43 27.93,124.43
DGND on L10_SIG03 (solid shape): 10.24,130.13 10.26,130.11 10.27,130.08 10.27,129.36 10.28,129.34 10.29,129.32 10.63,128.98 10.64,128.96 10.72,128.76 10.76,128.54 10.76,128.52 11.02,127.46 12.08,127.2 12.09,127.2 12.13,127.19 12.19,127.09 12.19,127.06 12.18,127.03 10.24,125.09 10.21,125.07 10.18,125.08 10.17,125.08 10.15,125.11 10.15,126.02 10.15,126.04 10.14,126.05 9.21,126.98 9.2,127 9.2,127.03 9.24,127.13 9.26,127.15 9.28,127.15 10.18,128.65 8.46,128.93 8.45,128.91 8.42,128.91 8.31,128.95 8.29,128.97 8.28,129 8.28,129.95 8.29,129.98 8.31,130 8.42,130.04 8.45,130.03 8.46,130.02 9.3,129.69 10.09,130.14 10.1,130.15 10.13,130.16
DGND on L10_SIG03 (solid shape): 36.44,44.1 36.47,44.11 36.5,44.11 36.6,44.06 36.62,44.04 36.62,44.02 36.74,43.75 37.03,43.69 37.05,43.69 37.07,43.69 37.14,43.63 37.16,43.61 37.16,43.59 37.16,43.52 37.16,43.5 37.15,43.48 35.33,41.67 35.32,41.65 35.32,41.63 35.32,39.66 35.31,39.63 35.24,39.47 35.27,39.3 35.28,39.29 35.27,39.26 35.22,39.18 35.2,39.16 35.18,39.16 35.04,39.16 35.02,39.16 35,39.18 34.95,39.26 34.94,39.29 34.95,39.3 34.65,39.77 34.35,39.3 34.35,39.29 34.35,39.26 34.3,39.18 34.28,39.16 34.25,39.16 33,39.16 32.97,39.16 32.95,39.18 32.9,39.27 32.9,39.3 32.91,39.31 32.95,39.56 32.8,39.77 32.79,39.77 32.78,39.79 32.77,39.88 32.77,39.91 32.78,39.93 35.24,42.38 35.25,42.4 35.25,42.42 35.25,42.89 35.26,42.91 35.27,42.92 35.3,42.96 35.34,42.97 35.38,42.96 35.39,42.93 35.92,42.76 35.85,43.32 35.84,43.32 35.83,43.34 35.81,43.44 35.81,43.46 35.83,43.48
DGND on L10_SIG03 (solid shape): outline of 139 points within 47.22,43.11 52.02,46.28
DGND on L10_SIG03 (solid shape): outline of 83 points within 41.67,144.73 52.42,147.71
DGND on L10_SIG03 (solid shape): 60.45,53.86 60.46,53.85 60.92,53.57 61.45,53.56 61.47,53.56 61.5,53.55 61.56,53.45 61.56,53.41 61.55,53.39 57.04,48.87 57.02,48.86 57,48.86 52.55,48.86 52.53,48.85 52.51,48.84 51.54,47.87 51.53,47.85 51.52,47.83 51.52,47.4 51.52,47.37 51.5,47.35 51.4,47.3 51.37,47.31 51.36,47.32 51.03,47.36 50.83,47.1 50.82,47.08 50.65,46.91 50.64,46.9 50.62,46.89 50.18,46.89 50.16,46.9 50.14,46.93 50.13,46.94 50.14,46.97 50.28,47.12 50.31,47.13 50.59,47.46 50.3,47.78 50.28,47.79 50.25,47.82 50.24,47.83 50.23,47.85 50.23,47.99 50.24,48.01 50.25,48.02 50.38,48.16 50.41,48.17 50.69,48.48 50.43,48.82 50.41,48.82 50.39,48.84 50.36,48.94 50.36,48.97 50.38,48.99 50.69,49.3 50.71,49.31 50.72,49.31 51.71,49.31 51.74,49.3 52.11,49.29 52.26,49.63 52.26,49.64 52.26,49.66 52.32,49.73 52.34,49.74 52.36,49.75 56.58,49.75 56.6,49.75 56.61,49.76 60.27,53.42 60.28,53.44 60.28,53.45 60.28,53.78 60.29,53.81 60.32,53.83 60.42,53.87
DGND on L10_SIG03 (solid shape): 40.5,39.47 40.52,39.48 40.55,39.48 40.57,39.47 40.58,39.45 40.58,38.55 40.59,38.53 40.6,38.52 40.83,38.28 40.84,38.26 41.18,37.98 41.5,38.29 41.5,38.3 41.52,38.32 41.62,38.36 41.64,38.36 41.67,38.35 43.44,36.58 43.45,36.57 43.47,36.57 45.19,36.57 45.21,36.56 45.23,36.54 45.29,36.46 45.29,36.43 45.28,36.42 45.26,36.21 45.36,36.03 45.37,36.02 45.38,35.99 45.34,35.89 45.32,35.87 45.29,35.86 44.95,35.86 44.93,35.86 44.91,35.88 44.85,35.95 44.85,35.97 44.85,35.98 44.53,36.39 44.21,35.98 44.21,35.97 44.21,35.95 44.15,35.88 44.13,35.86 44.11,35.86 41.3,35.86 41.27,35.87 41.25,35.89 41.21,35.99 41.22,36.02 41.23,36.03 41.01,36.61 40.79,36.03 40.8,36.02 40.81,35.99 40.77,35.89 40.75,35.87 40.72,35.86 40.03,35.86 40,35.87 39.98,35.89 39.94,35.99 39.95,36.02 39.96,36.03 40.07,36.31 39.92,36.56 39.91,36.57 39.9,36.59 39.89,36.68 39.89,36.7 39.9,36.72 40.15,36.96 40.16,36.98 40.16,37 40.16,39.11 40.17,39.13 40.18,39.15
DGND on L10_SIG03 (solid shape): outline of 138 points within 46.59,110.45 55.2,122.66
DGND on L10_SIG03 (solid shape): 37.99,88.28 38.01,88.27 38.06,88.24 38.08,88.24 38.4,88.24 38.52,88.19 38.79,87.97 39.1,88.11 39.11,88.12 39.13,88.13 39.14,88.13 39.18,88.12 39.19,88.08 39.19,88.05 39.15,87.87 39.21,87.7 39.22,87.69 39.22,87.66 39.18,87.57 39.16,87.55 39.13,87.54 38.93,87.54 38.91,87.53 38.89,87.52 38.51,87.15 38.47,87.15 38.46,87.16 37.87,87.13 37.93,86.54 37.94,86.53 37.95,86.5 37.95,86.43 37.94,86.4 37.93,86.38 37.79,86.19 37.79,85.96 37.79,85.95 37.79,85.93 37.73,85.85 37.71,85.84 37.69,85.83 37.42,85.83 37.4,85.84 37.39,85.85 37.32,85.91 37.31,85.93 37.31,85.95 37.31,86.14 37.3,86.16 37.29,86.18 37.1,86.38 37.09,86.39 37.08,86.42 37.09,86.5 37.1,86.52 37.11,86.53 37.29,86.89 37.08,87.22 37.07,87.23 37.05,87.25 37.05,87.36 37.06,87.39 37.11,87.42 37.2,87.41 37.23,87.39 37.83,87.39 37.78,87.99 37.77,88 37.76,88.02 37.76,88.1 37.77,88.13 37.78,88.14 37.83,88.19 37.88,88.25 37.9,88.27
DGND on L10_SIG03 (solid shape): 12.43,81.07 12.45,81.05 12.45,81.02 12.45,79.39 12.45,79.36 12.43,79.34 12.33,79.29 12.3,79.3 12.29,79.31 11.76,79.04 12.29,78.78 12.3,78.78 12.33,78.79 12.43,78.74 12.45,78.72 12.45,78.69 12.45,77.93 12.45,77.9 12.43,77.89 12.34,77.83 12.32,77.83 12.31,77.84 11.83,77.54 12.31,77.24 12.32,77.25 12.34,77.25 12.43,77.2 12.45,77.18 12.45,77.15 12.45,75.14 12.44,75.11 12.42,75.1 12.41,75.09 12.38,75.1 11.17,76.3 11.16,76.32 11.15,76.34 11.15,78.98 11.16,79.01 11.17,79.02 11.24,79.08 11.27,79.09 11.28,79.08 11.57,79.16 11.68,79.44 11.68,79.46 11.69,79.48 11.78,79.55 11.81,79.55 11.82,79.55 12.3,79.86 11.8,80.13 11.77,80.12 11.67,80.15 11.65,80.18 11.5,80.34 11.28,80.36 11.27,80.36 11.24,80.37 11.17,80.42 11.16,80.44 11.15,80.46 11.15,80.82 11.16,80.84 11.17,80.85 11.39,81.08 11.41,81.09 11.43,81.09 11.9,81.09 11.93,81.08 12.11,81.04 12.29,81.1 12.3,81.11 12.33,81.12
DGND on L10_SIG03 (solid shape): outline of 86 points within 35.11,86.59 37.3,89.55
DGND on L10_SIG03 (solid shape): outline of 165 points within 13.28,127.85 25.38,134.99
DGND on L10_SIG03 (solid shape): outline of 83 points within 33.74,106.25 34.83,109.17
DGND on L10_SIG03 (solid shape): outline of 169 points within 13.81,88.11 15.39,99.96
DGND on L10_SIG03 (solid shape): outline of 184 points within 1.6,63.75 7.42,75.32
DGND on L10_SIG03 (solid shape): outline of 101 points within 52.98,38.32 58.04,40.39
DGND on L10_SIG03 (solid shape): outline of 184 points within 36.93,104.31 38.86,106.56
DGND on L10_SIG03 (solid shape): outline of 201 points within 19.73,126.05 24.54,130.25
DGND on L10_SIG03 (solid shape): outline of 165 points within 52.21,101.94 72.93,127.76
DGND on L10_SIG03 (solid shape): 31.52,115.33 31.54,115.33 31.55,115.32 31.73,115.14 31.74,115.12 31.74,115.09 31.7,114.98 31.67,114.97 31.66,114.97 30.99,113.36 32.6,114.03 32.6,114.04 32.61,114.07 32.72,114.11 32.75,114.11 32.77,114.1 33.9,112.97 33.92,112.94 33.91,112.91 33.88,112.81 33.86,112.8 33.84,112.79 33.62,112.67 33.55,112.43 33.55,112.4 33.49,112.34 33.47,112.32 33.45,112.32 33.41,112.33 33.4,112.38 33.1,112.8 32.75,112.43 32.75,112.4 32.69,112.34 32.67,112.32 32.65,112.32 32.61,112.33 32.6,112.38 32.3,112.79 31.95,112.43 31.95,112.4 31.89,112.34 31.87,112.32 31.85,112.32 31.81,112.33 31.8,112.38 31.51,112.79 31.15,112.43 31.15,112.4 31.09,112.34 31.07,112.32 31.05,112.32 29.42,112.32 29.4,112.31 29.38,112.3 28.28,111.2 28.27,111.19 28.25,111.19 26.88,111.19 26.85,111.2 26.83,111.22 26.82,111.24 26.83,111.27 27.75,112.19 27.76,112.2 27.77,112.22 27.77,113.25 27.78,113.28 27.8,113.3 27.91,113.33 27.94,113.32 27.95,113.3 30.06,113.03 29.91,115.15 29.9,115.16 29.89,115.19 29.92,115.3 29.94,115.32 29.97,115.33
DGND on L10_SIG03 (solid shape): outline of 235 points within 24.74,67.62 54.33,82.69
DGND on L10_SIG03 (solid shape): outline of 113 points within 41.64,87.65 44.46,90.66
DGND on L10_SIG03 (solid shape): outline of 204 points within 49.47,104.87 59.2,123.41
DGND on L10_SIG03 (solid shape): outline of 260 points within 49.86,138.61 68.75,148.44
DGND on L10_SIG03 (solid shape): outline of 252 points within 6.84,131.1 14.52,135.92
DGND on L10_SIG03 (solid shape): outline of 107 points within 33.04,101.12 34.83,105.77
DGND on L10_SIG03 (solid shape): outline of 303 points within 44.87,128.99 53.39,136.45
DGND on L10_SIG03 (solid shape): outline of 324 points within 9.76,111.25 12.02,122.14
DGND on L10_SIG03 (solid shape): outline of 147 points within 42.11,85.39 47.2,87.46
DGND on L10_SIG03 (solid shape): outline of 379 points within 1.68,81 7.55,91.52
DGND on L10_SIG03 (solid shape): outline of 334 points within 12,139.17 25.93,144.45
DGND on L10_SIG03 (solid shape): outline of 381 points within 21.57,78.29 23.93,93.21
DGND on L10_SIG03 (solid shape): outline of 388 points within 2.64,132.02 14.04,139.12
DGND on L10_SIG03 (solid shape): outline of 491 points within 51.04,39.78 63.87,53.93
DGND on L10_SIG03 (solid shape): outline of 466 points within 52.22,103.88 71.56,130.26
DGND on L10_SIG03 (solid shape): outline of 544 points within 17.45,110.83 27.54,125.87
DGND on L10_SIG03 (solid shape): outline of 516 points within 14.88,107.93 26.28,126.81
DGND on L10_SIG03 (solid shape): outline of 671 points within 56.49,103.03 71.56,128.41
DGND on L10_SIG03 (solid shape): outline of 688 points within 22.62,66.37 53.12,74.63
DGND on L10_SIG03 (solid shape): outline of 791 points within 0.63,91.08 6.89,138.11
DGND on L10_SIG03 (solid shape): outline of 1125 points within 17.98,66.41 25.57,100.49
DGND on L10_SIG03 (solid shape): outline of 1538 points within 13.69,67.4 18.99,101.89
DGND on L10_SIG03 (solid shape): outline of 2100 points within 3.78,68.04 14.6,108.71
DGND on L10_SIG03 (solid shape): outline of 4129 points within 27.45,69.17 55.13,108.97
DGND on L10_SIG03 (solid shape): outline of 7957 points within 0.64,104.77 84.36,154.54
DGND on L10_SIG03 (solid shape): outline of 28645 points within 0.64,5.71 84.36,126.16
DGND on TOP: outline of 122 points within 0.64,5.71 84.36,154.54 ; 46 cut-outs
DGND on BOTTOM: 11.73,76.69 11.73,75.33 13.61,75.33 13.61,76.69
DGND on BOTTOM: 25.25,53.51 25.25,51.27 30.88,51.27 30.88,53.51
DGND on BOTTOM: 6.99,80.56 6.99,78.86 9.3,78.86 9.3,80.56
DGND on BOTTOM: 3.74,95.77 3.74,94.68 6.1,94.68 6.1,95.77
DGND on BOTTOM: 5.16,136.46 5.16,135.34 6.23,135.34 6.23,136.46
DGND on L02_GND01: 0.64,5.71 0.64,154.54 84.36,154.54 84.36,104.71 73.51,104.71 73.51,101.25 74.14,100.61 74.14,88.54 73.64,88.04 73.64,84.64 84.36,84.64 84.36,5.71
DGND on L04_GND02, L09_GND03: 0.64,154.54 84.36,154.54 84.36,104.71 73.51,104.71 73.51,101.25 74.14,100.61 74.14,88.54 73.64,88.04 73.64,84.64 84.36,84.64 84.36,5.71 0.64,5.71
DGND on L06_PWR01: 28.63,98.49 27.41,97.27 27.41,96.19 26.13,94.92 26.13,83.05 30.33,78.86 46.69,78.86 49.86,82.03 49.86,95.26 45.23,99.89 35.39,99.89 34.8,99.3 30.94,99.3 30.13,98.49
DGND on L06_PWR01: 7.55,5.73 7.55,18.84 42.38,18.84 42.6,18.26 42.82,18.84 49.25,18.84 49.25,5.73
DGND on L06_PWR01: 0.64,154.54 84.36,154.54 84.36,127.28 73.58,127.28 73.52,127.23 73.52,123.79 74.35,122.96 74.35,115.74 70.06,120.03 56.59,120.03 53.01,116.45 50.17,116.45 46.21,112.48 35.08,112.48 34.42,111.82 34.42,110.48 33.91,109.97 29.7,109.97 29.7,109.44 22.74,109.44 21.57,108.27 21.57,106.9 16,101.33 16,89.6 0.64,89.6
DGND on L06_PWR01: 69.04,63.92 84.33,63.92 84.33,23.94 83.8,23.41 78.49,23.41 77.32,24.58 77.32,35 69.04,43.28
DGND on L07_PWR02: 78.69,154.5 84.31,154.5 84.31,127.28 74.54,127.28 74.5,127.32 74.5,142.28 78.69,142.28
DGND on L07_PWR02: 76.33,38.9 76.33,64.22 84.37,64.22 84.37,38.9
DGND on L11_GND04: 0.64,154.54 84.36,154.54 84.36,104.71 73.51,104.71 73.51,101.25 74.14,100.61 74.14,88.54 73.51,87.91 73.51,84.64 84.36,84.64 84.36,5.71 0.64,5.71
VBUS_5V0_TYPEA on TOP: 67.29,71.28 67.29,69.13 68.58,67.83 73.66,67.83 73.66,69.6 69.69,69.6 68.82,70.46 68.82,71.28
VBUS_5V0_TYPEA on BOTTOM: 68.28,70.17 68.28,67.7 73.61,67.7 73.61,70.17
VBUS_5V0_TYPEA on L06_PWR01: 68.43,83.2 70.03,83.2 70.03,73.57 73.81,69.79 73.81,68.47 73.59,68.24 73.08,68.24 68.43,72.89
VBUS_TYPEC1 on L07_PWR02 (solid shape): outline of 1697 points within 4.67,42.29 18.54,53.04
VBUS_TYPEC2 on BOTTOM (solid shape): 14.52,43.95 14.54,43.95 14.58,43.92 15.44,43.92 15.46,43.93 15.5,43.95 16.49,43.95 16.54,43.9 17.34,43.9 17.37,43.89 17.39,43.85 17.39,43.31 17.37,43.28 17.34,43.26 16.5,43.26 16.47,43.23 16.47,43.23 16.22,42.98 16.2,42.97 16.18,42.96 15.4,42.96 15.38,42.96 15.37,42.95 15.09,42.67 15.08,42.66 15.08,42.64 15.08,41.13 15.06,41.1 15.03,41.08 14.11,41.08 14.07,41.1 14.06,41.13 14.06,43.52 14.06,43.54 14.07,43.56 14.45,43.94 14.47,43.95 14.49,43.95
VBUS_TYPEC2 on BOTTOM (solid shape): outline of 504 points within 5.2,26.45 17.5,43.55
VBUS_TYPEC2 on L06_PWR01: 4.85,32.63 4.85,27.53 9.22,27.53 9.22,32.63
VBUS_TYPEC2 on L07_PWR02: 14.96,44.17 25.99,44.17 25.99,26.44 11.2,26.44 10.45,27.2 5.34,27.2 4.74,27.8 4.74,32.5 5.14,32.91 8.84,32.91 11.08,35.15 11.08,40.3
VCC1V1 on TOP: 23.03,74.61 26.16,74.61 26.16,73.5 27.57,73.5 27.57,69.45 23.02,69.45 22.25,68.68 20.58,68.68 20.58,71.25 22.48,71.25 23.03,71.81
VCC1V1 on BOTTOM: 20.6,71.51 20.6,68.67 22.33,68.67 22.33,71.51
VCC1V1_SW on TOP: 22.34,71.99 20.71,71.99 20.71,74.3 19.6,75.42 19.6,76.13 19.65,76.18 21.03,76.18 22.34,74.87
VCC1V8_SYS on TOP: 2.75,86.07 7.98,86.07 9.3,84.75 9.3,81.09 7.32,81.09 5.31,83.1 2.75,83.1
VCC1V8_SYS on BOTTOM: 65.89,52.54 65.89,51.8 67.36,51.8 67.36,52.54
VCC1V8_SYS on BOTTOM: 5.49,86.38 5.9,85.97 9.1,85.97 9.1,81.75 7.27,81.75 5.69,83.33 4.04,83.33 4.04,86.38
VCC1V8_SYS on L07_PWR02: 22.23,68.01 0.64,68.01 0.64,83.37 1.49,84.22 7.89,84.22 10.85,81.26 21.99,81.26 22.39,80.86 22.39,76.59 24.03,74.94 50.35,74.94 51.64,76.24 51.64,87.87 53.81,90.04 57.59,90.04 61.54,93.98 61.54,100.31 63.93,102.71 63.93,107.91 61.32,110.53 61.32,111.48 53.94,118.86 31.32,118.86 23.47,126.71 12.83,126.71 12.83,137.1 10.14,139.79 1.37,139.79 1.37,154.1 49.76,154.1 49.76,143.25 50.52,142.48 73.51,142.48 73.51,101.31 74.15,100.67 74.15,88.56 73.51,87.92 73.51,82.26 72.18,80.93 72.16,80.93 71.52,80.29 71.52,56.62 70.69,55.79 67.21,55.79 67.21,52.69 66.19,51.68 62.49,51.68 57.81,47 57.81,43.73 59.24,42.3 59.24,35.88 53.67,35.88 52.48,37.07 52.48,52.77 51.22,54.03 30.21,54.03 24.79,59.45 24.2,59.45 23,60.65 23,67.23
VCC1V8_SYS_SW on TOP: 9.88,83.35 11.2,83.35 11.43,83.12 11.43,81.7 12.29,80.84 12.01,80.56 11.41,80.56 11.08,80.89 9.88,80.89
VCC3V3_EXP on BOTTOM: 8.16,129.17 8.16,126.3 10.37,126.3 10.37,129.17
VCC3V3_EXP on BOTTOM: 16.74,132.6 18.6,132.6 18.6,134.13 16.89,134.13 16.74,133.97
VCC3V3_EXP on L06_PWR01: 7.8,125.74 7.8,132.93 9.32,134.46 50.1,134.46 50.1,127.04 13.77,127.04 12.47,125.74
VCC3V3_TA on TOP: 44.85,15.42 44.85,12.88 47.74,12.88 47.74,16.41 45.84,16.41
VCC3V3_TA on BOTTOM: 46.98,58.96 46.75,59.19 43.6,59.19 43.43,59.36 42.33,59.36 42.03,59.06 34.03,59.06 33.57,58.6 32.4,58.6 32.33,58.68 32.33,60.76 32.73,61.17 38.4,61.17 39.39,60.18 40.76,60.18 41.12,60.53 44.11,60.53 44.47,60.18 47.21,60.18 48,59.39 48,56.67 53.76,56.67 53.76,54.13 52.8,54.13 52.75,54.18 52.75,55.45 49.52,55.45 49.52,52.51 49.47,52.46 47.77,52.46 47.64,52.58 47.64,53.04 47.41,53.27 47.08,53.27 46.98,53.37
VCC3V3_TA on BOTTOM: 74.37,12.66 74.37,16.09 72.6,16.09 72.6,12.66
VCC3V3_TA on L07_PWR02: 76.46,6.29 35.11,6.29 35.11,22.95 32.29,25.77 32.29,36.69 38.31,42.71 38.31,52.9 39.01,53.6 51.17,53.6 51.87,52.9 51.87,35.32 53.37,33.82 60.56,33.82 60.56,37.76 60.96,38.16 84,38.16 84,23.94 77.32,23.94 76.46,23.08
VCC3V3_XDS on BOTTOM: 71.97,25.74 75.22,25.74 75.22,24.39 72.46,24.39 71.97,24.88
VCC3V3_XDS on L06_PWR01: 76.46,8.34 74.32,6.21 50.17,6.21 50.17,20.33 59.84,30 59.84,32.8 65.06,38.03 65.06,37.54 68.57,41.05 70.53,41.05 76.46,35.12
VCC5V0_EXP on BOTTOM: 6.5,136.92 7.09,136.92 7.39,136.61 7.39,135.01 7.11,134.74 6.78,134.74 6.48,135.04 6.48,136.89
VCC5V0_EXP on BOTTOM: 7.86,132.63 7.86,129.73 12.94,129.73 12.94,132.63
VCC5V0_EXP on L03_SIG01: 6.91,136.49 9.81,136.49 12.83,133.47 12.83,130.29 12.14,129.6 9.17,129.6 6.58,132.2 6.58,136.16
VCC_0V85 on TOP: 22.27,80.93 24.07,80.93 24.07,79.5 22.74,79.5 22.09,80.16 22.09,80.75
VCC_0V85 on BOTTOM: 22.1,86.3 22.1,84.6 23.32,84.6 23.32,86.02 23.04,86.3
VCC_0V85 on L08_PWR03: 22.13,85.1 23.45,85.1 23.74,84.81 23.74,79.54 22.13,79.54
VCC_1V8_AUD on BOTTOM: 66.68,51.35 69.14,51.35 69.24,51.25 70.03,51.25 70.08,51.19 71.33,51.19 71.33,50.64 66.68,50.64
VCC_1V8_FT4232 on L10_SIG03: 13.59,19.44 14.53,20.38 31.5,20.38 32.54,19.34 32.54,12.15 31.75,11.37 14.3,11.37 13.59,12.08
VCC_3V3_AUD on BOTTOM: 68.19,45.37 69.94,45.37 69.94,43.44 68.19,43.44
VCC_3V3_AUD on L07_PWR02: 68.02,55.06 75.08,55.06 75.75,54.4 75.75,38.8 60.15,38.8 60.15,42.41 58.52,44.03 58.52,46.6 62.94,51.02 66.47,51.02 68.02,52.57
VCC_3V3_FT4232 on BOTTOM: 11.82,13.52 11.82,11.44 11.27,11.44 11.27,10.55 13.04,10.55 13.91,11.41 13.91,13.52
VCC_3V3_FT4232 on L07_PWR02: 9.12,24.9 27.44,24.9 29.36,22.98 29.36,20.51 28.32,19.47 25.53,19.47 25.53,15.99 34.29,15.99 34.29,6.62 9.12,6.62
VCC_3V3_MAIN on TOP: 20.25,88.25 19.04,88.25 19.04,87.15 18.88,86.98 18.88,84.6 19.06,84.42 19.42,84.42 20.25,85.25
VCC_3V3_MAIN on TOP: 20.01,71.33 19.23,71.33 19.04,71.53 19.04,72.44 18.88,72.6 18.88,74.98 19.06,75.16 19.42,75.16 20.25,74.33 20.25,71.57
VCC_3V3_MAIN on TOP: 13.73,88.25 14.93,88.25 14.93,87.15 15.1,86.98 15.1,84.6 14.91,84.42 14.56,84.42 13.73,85.25
VCC_3V3_MAIN on TOP: 24.25,53.79 24.25,58.64 41.15,58.64 42.9,56.88 45.61,56.88 45.61,56.3 45.75,56.16 45.75,54.94 44.53,54.94 44.21,54.62 44.21,53.79
VCC_3V3_MAIN on TOP: 10.03,80.27 11.41,80.27 11.46,80.21 12.18,80.21 12.3,80.1 12.3,79.9 11.56,79.16 11.28,79.16 11.08,78.96 10.06,78.96 9.96,79.06 9.96,80.2
VCC_3V3_MAIN on TOP: 13.95,71.33 14.73,71.33 14.93,71.54 14.93,72.44 15.1,72.6 15.1,74.98 14.91,75.16 14.56,75.16 13.73,74.33 13.73,71.56
VCC_3V3_MAIN on BOTTOM: 14.32,76.38 16.13,76.38 16.45,76.06 16.45,74.41 16.29,74.26 15.76,74.26 15.55,74.46 15.55,75.09 15.26,75.39 14.32,75.39
VCC_3V3_MAIN on BOTTOM: 20.5,84.62 21.52,84.62 22.13,84.01 22.13,79.09 22.4,78.82 22.4,77.3 21.94,76.85 20.53,76.85 20.53,80.63 20.35,80.81 20.35,81.47 20.5,81.62
VCC_3V3_MAIN on BOTTOM: 4.43,61.84 5.07,61.84 5.07,63.44 4.43,63.44
VCC_3V3_MAIN on BOTTOM: 10.11,80.53 10.11,78.91 12.25,78.91 12.25,80.53
VCC_3V3_MAIN on BOTTOM: 13.66,71.59 13.66,74.38 14.91,74.38 14.91,71.54 14.72,71.35 13.9,71.35
VCC_3V3_MAIN on BOTTOM: 20.31,71.35 20.31,74.38 19.06,74.38 19.06,71.54 19.25,71.35
VCC_3V3_MAIN on BOTTOM: 13.66,88.23 13.66,85.23 14.91,85.23 14.91,88.04 14.72,88.23
VCC_3V3_MAIN on BOTTOM: 24.19,60.1 24.19,53.88 31.59,53.88 31.59,60.1
VCC_3V3_MAIN on BOTTOM: 20.31,87.96 20.31,85.21 19.06,85.21 19.06,88.04 19.25,88.23 20.04,88.23
VCC_3V3_MAIN on L06_PWR01: 0.87,88.91 16.94,88.91 16.94,101.45 19.12,103.63 20.18,103.63 21.65,102.16 21.65,101.65 19.26,99.25 19.26,91.91 22,89.17 22,81.29 25.2,78.09 43.69,78.09 43.69,53.47 2.63,53.47 0.87,55.23
VCC_3V3_SYS on TOP: 9.51,153.09 13.64,153.09 13.64,151.85 11.81,151.85 11.53,152.13 9.51,152.13
VCC_3V3_SYS on TOP: 8.95,101.18 10.14,101.18 10.35,101.38 13.24,101.38 13.24,100.47 8.88,100.47 8.88,101.11
VCC_3V3_SYS on TOP: 61.25,49.26 61.25,47.12 61.35,47.02 62.33,47.02 62.45,47.15 62.45,49.23 62.38,49.31 61.3,49.31
VCC_3V3_SYS on TOP: 9.51,134.5 13.53,134.5 13.53,135.77 11.85,135.77 11.53,135.45 9.51,135.45
VCC_3V3_SYS on TOP: 47.23,54.89 47.23,58.39 51.74,58.39 51.74,54.89
VCC_3V3_SYS on TOP: 11.38,96.99 11.38,95.67 11.06,95.35 11.06,93.51 11.71,93.51 12.51,94.32 14.5,94.32 14.5,96.99
VCC_3V3_SYS on TOP: 74.45,153.62 76.71,153.62 76.71,147.82 74.45,147.82
VCC_3V3_SYS on BOTTOM: 13.24,63.01 13.24,59.14 15.57,59.14 15.57,63.01
VCC_3V3_SYS on BOTTOM: 64.83,132.78 65.29,132.78 65.29,132 66.21,132 66.21,131.76 65.58,131.13 65.1,131.13 64.78,131.45 64.78,132.73
VCC_3V3_SYS on BOTTOM: 66.65,44.84 66.65,42.61 67.85,42.61 67.85,44.84
VCC_3V3_SYS on BOTTOM: 64.62,84.77 64.62,80.65 63.12,80.65 63.12,83.91 62.13,83.91 62.13,84.7 63.4,84.7 63.47,84.77
VCC_3V3_SYS on BOTTOM: 8.03,110.94 10.67,110.94 10.67,109.71 11.75,109.71 12.59,110.55 12.9,110.55 13.05,110.7 13.05,113.06 13.25,113.26 13.71,113.26 13.81,113.16 13.81,110.57 13.43,110.19 12.79,110.19 11.63,109.02 11.63,107.94 14.3,107.94 14.3,106.77 10.06,106.77 9.1,107.74 9.1,109.46 8.26,110.3 8.03,110.3
VCC_3V3_SYS on BOTTOM: 71.22,110.23 71.22,108.63 72.65,108.63 72.65,110.23
VCC_3V3_SYS on BOTTOM: 58.69,78.76 58.69,77.29 59.66,77.29 59.66,78.76
VCC_3V3_SYS on BOTTOM: 76.46,150.15 77.54,150.15 77.67,150.03 77.67,149.41 77.77,149.31 80.41,149.31 80.46,149.26 80.46,147.33 80.03,146.89 76.62,146.89 76.46,147.06
VCC_3V3_SYS on BOTTOM: 16.61,136.41 18.34,136.41 18.47,136.28 18.47,135.5 17.35,134.38 16.79,134.38 16.61,134.56
VCC_3V3_SYS on BOTTOM: 71.22,87.67 71.22,86.07 72.65,86.07 72.65,87.67
VCC_3V3_SYS on L06_PWR01: 9.48,109.67 11.03,109.67 13.03,107.66 13.03,101.03 12.7,100.7 10.57,100.7 8.97,102.3 8.97,109.16
VCC_3V3_SYS on L08_PWR03: 0.64,154.54 84.36,154.54 84.36,5.71 0.64,5.71 ; 8 cut-outs
VCC_5V0 on BOTTOM (solid shape): 19.99,35.62 20.01,35.62 20.03,35.6 20.08,35.51 20.08,35.48 20.07,35.47 20.36,34.98 20.65,35.47 20.64,35.48 20.64,35.51 20.69,35.6 20.71,35.62 20.74,35.62 21.33,35.62 21.37,35.61 21.38,35.57 21.38,32.94 21.39,32.92 21.4,32.9 21.5,32.8 21.5,32.79 21.57,32.69 21.68,32.61 21.71,32.6 21.73,32.59 21.81,32.59 21.85,32.59 22.64,32.59 22.68,32.58 22.69,32.54 22.69,31.28 22.68,31.24 22.64,31.23 18.76,31.23 18.72,31.24 18.71,31.28 18.71,32.96 18.69,32.99 18.66,33.01 16.77,33.01 16.73,33.02 16.72,33.06 16.72,35.57 16.73,35.61 16.77,35.62
VCC_5V0 on TOP: 63.76,66.65 63.76,71.18 65.68,71.18 65.68,66.65
VCC_5V0 on BOTTOM: 57.66,147.41 58.72,147.41 58.72,146.45 58.95,146.22 58.95,142.12 57.23,142.12 57.23,144.95 57.66,145.38
VCC_5V0 on BOTTOM: 0.76,116.37 0.76,117.44 3.69,117.44 3.69,116.98 1.98,116.98 1.98,116.37
VCC_5V0 on BOTTOM: 7.01,138.24 8.21,138.24 8.21,137.07 7.44,137.07 7.37,137.15 6.5,137.15 6.5,137.71 6.89,137.71 7.01,137.83
VCC_5V0 on L06_PWR01: 7.56,145.75 58.12,145.75 59.38,144.49 59.38,127.12 57.51,125.25 57.51,121.96 58.35,121.12 61.25,121.12 63.9,118.47 63.9,116.41 65.02,115.3 65.83,115.3 67.56,113.57 67.56,111.51 67.33,111.28 65.98,111.28 65.47,111.79 65.47,111.8 60.7,116.57 50.76,116.57 50.76,135.09 6.62,135.09 6.02,134.49 5.08,134.49 4.63,134.95 4.63,142.81
VCC_5V0 on L06_PWR01: 48,19.55 59.28,30.83 59.28,32.73 68.13,41.58 68.13,71.13 67.41,71.84 51.23,71.84 51.23,62.88 48.47,60.11 48.47,52.67 47.5,51.7 47.5,45.53 45.98,44.01 45.98,38.44 37.42,29.88 22.29,29.88 21.61,30.57 21.61,34.81 20.69,35.72 11.97,35.72 11.97,19.55
VCC_5V0 on L07_PWR02: 0.64,139.08 9.22,139.08 10.87,137.43 10.87,112.99 0.64,112.99
VCC_5V0 on L08_PWR03: 69.95,113.79 69.95,67.48 68.81,66.33 64.29,66.33 63.81,66.82 63.81,72.35 64.23,72.77 64.23,83.86 63.81,84.28 63.81,89.93 64.23,90.35 64.23,112.78 64.28,112.83 64.28,113.01 65.55,114.28 65.55,114.31 69.44,114.31
