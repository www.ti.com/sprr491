# Allegro board PROC135A_BRD.BRD (continued)
## Nets (continued)
CPSW_ETH1_LED0: TP18.1(TP) U78.47(LED_0)
CPSW_ETH1_LED_1000: R86.1 R327.1 R336.2 TP23.1(TP) U78.46(LED_1)
CPSW_ETH1_LED_ACT: R85.1 R337.2 R364.1 TP22.1(TP) U78.45(LED_2)
CPSW_ETH2_D0N: J24.10(MX0-) U125.2(TD_M_A)
CPSW_ETH2_D0P: J24.9(MX0+) U125.1(TD_P_A)
CPSW_ETH2_D1M: J24.8(MX1-) U125.5(TD_M_B)
CPSW_ETH2_D1P: J24.7(MX1+) U125.4(TD_P_B)
CPSW_ETH2_D2M: J24.6(MX2-) U125.8(TD_M_C)
CPSW_ETH2_D2P: J24.5(MX2+) U125.7(TD_P_C)
CPSW_ETH2_D3M: J24.4(MX3-) U125.11(TD_M_D)
CPSW_ETH2_D3P: J24.3(MX3+) U125.10(TD_P_D)
CPSW_ETH2_GPIO_0: R586.1 R588.1 R592.1 R605.2 TP120.1(TP)
CPSW_ETH2_GPIO_1: R584.1 R594.2 R601.1 TP118.1(TP)
CPSW_ETH2_LED0: TP122.1(TP) U125.47(LED_0)
CPSW_ETH2_LED_1000: R591.1 R598.2 R603.1 TP121.1(TP) U125.46(LED_1)
CPSW_ETH2_LED_ACT: R587.1 R596.1 R604.2 TP119.1(TP) U125.45(LED_2)
CPSW_ETH_INTN: R53.1 R78.1
CPSW_RGMII1_ETH1_CLK: R26.2 U78.15(XI)
CPSW_RGMII1_ETH1_CLK_OUT: TP28.1(TP) U78.18(CLK_OUT)
CPSW_RGMII1_ETH1_RBIAS: C307.2 R351.1 U78.12(RBIAS)
CPSW_RGMII1_MDC: R108.2 R354.1 U78.16(MDC)
CPSW_RGMII1_MDIO: R107.2 R355.2 U78.17(MDIO)
CPSW_RGMII1_RD0: R96.2 R347.1 U18.AB16(RGMII1_RD0) U78.33(RX_D0)
CPSW_RGMII1_RD1: U18.V15(RGMII1_RD1) U78.34(RX_D1)
CPSW_RGMII1_RD2: R93.2 R346.1 U18.W15(RGMII1_RD2) U78.35(RX_D2)
CPSW_RGMII1_RD3: U18.V14(RGMII1_RD3) U78.36(RX_D3)
CPSW_RGMII1_RESETN: R440.1 U41.4(Y) U78.43(RESET_N)
CPSW_RGMII1_RX_CTL: R339.2 R340.2 U18.AA15(RGMII1_RX_CTL) U78.38(RX_DV/RX_CTRL)
CPSW_RGMII1_RXC: R348.1 U18.AA16(RGMII1_RXC)
CPSW_RGMII1_TD0: U18.Y17(RGMII1_TD0) U78.28(TX_D0)
CPSW_RGMII1_TD1: U18.V16(RGMII1_TD1) U78.27(TX_D1)
CPSW_RGMII1_TD2: U18.Y16(RGMII1_TD2) U78.26(TX_D2)
CPSW_RGMII1_TD3: U18.AA17(RGMII1_TD3) U78.25(TX_D3)
CPSW_RGMII1_TX_CTL: U18.W16(RGMII1_TX_CTL) U78.37(TX_EN/TX_CTRL)
CPSW_RGMII1_TXC: R322.2 U78.29(GTX_CLK)
CPSW_RGMII2_ETH2_CLK: R37.2 U125.15(XI)
CPSW_RGMII2_ETH2_CLK_OUT: TP126.1(TP) U125.18(CLK_OUT)
CPSW_RGMII2_ETH2_RBIAS: C556.2 R611.1 U125.12(RBIAS)
CPSW_RGMII2_MDC: R606.2 R609.2 U125.16(MDC)
CPSW_RGMII2_MDIO: R607.1 R608.2 U125.17(MDIO)
CPSW_RGMII2_RD0: R597.1 R599.2 U18.AA21(RGMII2_RD0) U125.33(RX_D0)
CPSW_RGMII2_RD1: U18.Y20(RGMII2_RD1) U125.34(RX_D1)
CPSW_RGMII2_RD2: R595.2 R600.1 U18.AB21(RGMII2_RD2) U125.35(RX_D2)
CPSW_RGMII2_RD3: U18.AB20(RGMII2_RD3) U125.36(RX_D3)
CPSW_RGMII2_RSTN: R314.1 U42.4(Y) U125.43(RESET_N)
CPSW_RGMII2_RX_CTL: R593.2 R602.2 U18.W18(RGMII2_RX_CTL) U125.38(RX_DV/RX_CTRL)
CPSW_RGMII2_RXC: R582.1 U18.AA20(RGMII2_RXC)
CPSW_RGMII2_TD0: U18.AA19(RGMII2_TD0) U125.28(TX_D0)
CPSW_RGMII2_TD1: U18.Y18(RGMII2_TD1) U125.27(TX_D1)
CPSW_RGMII2_TD2: U18.AA18(RGMII2_TD2) U125.26(TX_D2)
CPSW_RGMII2_TD3: U18.W17(RGMII2_TD3) U125.25(TX_D3)
CPSW_RGMII2_TX_CTL: U18.Y19(RGMII2_TX_CTL) U125.37(TX_EN/TX_CTRL)
CPSW_RGMII2_TXC: R56.2 U125.29(GTX_CLK)
CPSW_RGMII2_TXC_R: R56.1 U18.AB19(RGMII2_TXC)
CPSW_RGMII_INTN: R78.2 R335.1 R610.2 U78.44(INT/PWDN) U125.44(INT/PWDN)
CPSW_RGMII_TXC_R: R322.1 U18.AB17(RGMII1_TXC)
CS_LM5141: L10.2 R397.1 U89.18(CS)
CSI0_FLEX_RXCLKN: J20.8 U8.28(D0-B)
CSI0_FLEX_RXCLKP: J20.9 U8.29(D0+B)
CSI0_FLEX_RXN0: J20.2 U8.26(D1-B)
CSI0_FLEX_RXN1: J20.5 U8.24(D2-B)
CSI0_FLEX_RXN2: J20.11 U8.22(D3-B)
CSI0_FLEX_RXN3: J20.14 U8.20(CEC_B)
CSI0_FLEX_RXP0: J20.3 U8.27(D1+B)
CSI0_FLEX_RXP1: J20.6 U8.25(D2+B)
CSI0_FLEX_RXP2: J20.12 U8.23(D3+B)
CSI0_FLEX_RXP3: J20.15 U8.21(HPD_B)
CSI0_MIPI_RXCLKN: J1.7 U8.37(D0-A)
CSI0_MIPI_RXCLKP: J1.5 U8.38(D0+A)
CSI0_MIPI_RXN0: J1.11 U8.35(D1-A)
CSI0_MIPI_RXN1: J1.15 U8.33(D2-A)
CSI0_MIPI_RXN2: J1.19 U8.31(D3-A)
CSI0_MIPI_RXN3: J1.23 U8.18(CEC_A)
CSI0_MIPI_RXP0: J1.9 U8.36(D1+A)
CSI0_MIPI_RXP1: J1.13 U8.34(D2+A)
CSI0_MIPI_RXP2: J1.17 U8.32(D3+A)
CSI0_MIPI_RXP3: J1.21 U8.19(HPD_A)
CSI0_RXCLKN: U8.6(D0-) U18.AB14(CSI0_RXCLKN)
CSI0_RXCLKP: U8.5(D0+) U18.AB13(CSI0_RXCLKP)
CSI0_RXN0: U8.8(D1-) U18.W12(CSI0_RXN0)
CSI0_RXN1: U8.11(D2-) U18.Y13(CSI0_RXN1)
CSI0_RXN2: U8.13(D3-) U18.AA13(CSI0_RXN2)
CSI0_RXN3: U8.15(CEC) U18.AB11(CSI0_RXN3)
CSI0_RXP0: U8.7(D1+) U18.W13(CSI0_RXP0)
CSI0_RXP1: U8.10(D2+) U18.Y14(CSI0_RXP1)
CSI0_RXP2: U8.12(D3+) U18.AA12(CSI0_RXP2)
CSI0_RXP3: U8.14(HPD) U18.AB10(CSI0_RXP3)
CSI0_RXRCALIB: R328.2 U18.V10(CSI0_RXRCALIB)
CSI_EN: R292.2 U2.21(P24) U8.2(EN)
CSI_GPIO0: J20.17 U4.20(B1) U92.14(P15)
CSI_GPIO1: J20.18 U4.18(B2) U92.15(P16)
CSI_GPIO2: U4.17(B3) U55.6(2B2)
CSI_GPIO3: U4.16(B4) U55.3(1B2)
CSI_GPIO4: U4.15(B5) U55.10(3B2)
CSI_I2C2_NINT1: R29.2 U5.8(I\N\T\1\)
CSI_I2C2_SCL: J20.20 R31.2 U3.8(SCL_B) U5.10(SC1)
CSI_I2C2_SDA: J20.21 R30.2 U3.1(SDA_B) U5.9(SD1)
CSI_I2C_LT_EN: R4.1 R5.2 U3.6(OE)
CSI_MIPI_GPIO0: J1.6 U4.1(A1)
CSI_MIPI_GPIO1: J1.8 U4.3(A2)
CSI_MIPI_GPIO2: J1.18 U4.4(A3)
CSI_MIPI_GPIO3: J1.20 U4.5(A4)
CSI_MIPI_GPIO4: J1.22 U4.6(A5)
CSI_MIPI_I2C2_SCL: J1.2 R246.2 U3.5(SCL_A)
CSI_MIPI_I2C2_SDA: J1.4 R249.2 U3.4(SDA_A)
CSI_MIPI_LT_EN: R20.1 R21.2 U4.10(OE)
CSI_MIPI_RSTZ: J1.14 R255.1 U4.7(A6)
CSI_REFCLK: J1.10 R34.2 TP1.1(TP)
CSI_RSTZ: U2.10(P11) U4.14(B6)
CSI_SEL1: R39.2 U8.16(SEL1)
CSI_SEL2: R38.2 U2.20(P23) U8.17(SEL2)
CSI_VLDO_SEL: R251.1 U2.23(P26) U50.1(EN1)
DEBOUNCE_CAN_FD_WKUP: C110.2 D3.2 R149.2 SW1.2 SW1.3 U35.1(1A)
DEBOUNCE_GPIO_INT_MCU_SOC: C484.2 D12.2 Q13.2(S) R538.2 SW5.2 SW5.3 U108.3(2A)
DEBOUNCE_MCU_RESETZ: C134.2 Q3.2(S) R183.2 TP70.1(TP) U108.1(1A)
DEBOUNCE_SOC_WARMRESETN: C485.2 D13.2 Q14.2(S) R539.2 SW4.2 SW4.3 U108.6(3A)
DIR: R480.1 U98.2(DIR) U101.2(DIR)
DRAIN1: U90.8(DRAIN1_1) U90.15(DRAIN1_2) U90.19(DRAIN1_3) U90.58(DRAIN1_4)
DRAIN2: U90.7(DRAIN2_1) U90.52(DRAIN2_2) U90.56(DRAIN2_3) U90.57(DRAIN2_4)
EEPROM_A0: R151.2 U38.1(A0)
EEPROM_A1: R154.1 U38.2(A1)
EEPROM_A2: R156.1 U38.3(A2)
EEPROM_WP: R155.1 U38.7(WP)
EMMC_RSTN: R133.2 U28.K5(RST_N) U32.4(Y)
EN_DRV_OUT: TP31.1(TP) U27.29(EN_DRV)
EN_LM5141_ON: R81.2 R444.1 U89.23(EN)
ETH1_EARTH: C346.1 J6.15(SH1) J6.16(SH2) R121.1
ETH2_EARTH: C555.1 J24.15(SH1) J24.16(SH2) R583.1
ETH_CAN_INH: R73.2 R75.2 R76.2 R82.1
ETH_CAN_INH_PREREG: R76.1 R81.1
ETH_CAN_INH_SOC: R65.2 R73.1 R88.1
EXP_CLKOUT0: J3.7 R59.1
EXP_EHRPWM1_B: J3.33 U18.B20(MCASP0_AXR0)
EXP_GPIO0_14: J3.22 U10.7(B1)
EXP_GPIO0_14_LT: U10.2(A1) U18.G20(OSPI0_CSN3)
EXP_GPIO0_32: J3.30 R52.1
EXP_GPIO0_33: J3.31 U18.L17(GPMC0_OEN_REN)
EXP_GPIO0_36: J3.29 U18.M18(GPMC0_BE1N)
EXP_GPIO0_38: J3.16 U18.R17(GPMC0_WAIT1)
EXP_GPIO0_39: J3.18 U18.K17(GPMC0_WPN)
EXP_GPIO0_40/PR0_ECAP0_IN_APWM_: J3.32 U18.K18(GPMC0_DIR)
EXP_GPIO0_41: J3.37 U18.M19(GPMC0_CSN0)
EXP_GPIO0_42: J3.13 U18.M21(GPMC0_CSN1)
EXP_GPIO1_22: J3.15 U18.F14(UART0_CTSN)
EXP_HAT_DETECT: J3.39 R172.1 U92.8(P07)
EXP_I2C2_NINT0: R17.2 U5.4(I\N\T\0\)
EXP_I2C2_SCL: J3.5 R293.2 U5.6(SC0)
EXP_I2C2_SDA: J3.3 R294.2 U5.5(SD0)
EXP_PS_3V3_EN: R286.2 U57.B2(ON) U92.6(P05)
EXP_PS_5V0_EN: R271.2 U53.C2(ON) U92.7(P06)
EXP_SPI0_CLK: J3.23 U55.2(1B1)
EXP_SPI0_CS0: J3.24 R290.2 U55.11(3B1)
EXP_SPI0_CS1: J3.26 R289.2 U18.C16(SPI0_CS1)
EXP_SPI0_D0: J3.19 U55.5(2B1)
EXP_SPI0_D1: J3.21 U18.E15(SPI0_D1)
EXP_SPI2_CLK: J3.12 U95.5(2B1)
EXP_SPI2_CS0/EHRPWM0_A: J3.35 R287.2 U95.2(1B1)
EXP_SPI2_CS1: J3.11 R288.2 U18.A19(MCASP0_ACLKX)
EXP_SPI2_CS2: J3.36 R291.2 U18.B18(MCASP0_AXR1)
EXP_SPI2_D0: J3.40 U95.11(3B1)
EXP_SPI2_D1/ECAP2_IN_APWM_OUT: J3.38 U95.14(4B1)
EXP_UART5_RXD: J3.10 U18.B17(MCAN0_TX)
EXP_UART5_TXD: J3.8 U18.C18(MCAN0_RX)
EXT_CLKOUT0: R28.1 R60.1
EXT_CLKOUT0_R: R59.2 R60.2 U18.B16(EXT_REFCLK1)
FT4232_DO: R508.1 R513.2 U113.4(DO)
FT4232_EECLK: R509.1 U48.62(EECLK) U113.2(CLK)
FT4232_EECS: R510.1 U48.63(EECS) U113.1(CS)
FT4232_EEDATA: R513.1 U48.61(EEDATA) U113.3(DI)
FT4232_MCU_UART0_CTS_3V3: U48.53(DDBUS2) U110.12(2B2)
FT4232_MCU_UART0_RTS_3V3: U48.54(DDBUS3) U110.14(1B2)
FT4232_MCU_UART0_RX_3V3: U48.48(DDBUS0) U110.13(2B1)
FT4232_MCU_UART0_TX_3V3: U48.52(DDBUS1) U110.15(1B1)
FT4232_REF: R553.2 U48.6(REF)
FT4232_RESET: C160.2 R235.1 U48.14(R\E\S\E\T\)
FT4232_SOC_UART0_RX_3V3: U48.16(ADBUS0) U119.13(2B1)
FT4232_SOC_UART0_TX_3V3: U48.17(ADBUS1) U119.15(1B1)
FT4232_SOC_UART1_CTS_3V3: U48.28(BDBUS2) U123.12(2B2)
FT4232_SOC_UART1_RTS_3V3: U48.29(BDBUS3) U123.14(1B2)
FT4232_SOC_UART1_RX_3V3: U48.26(BDBUS0) U123.13(2B1)
FT4232_SOC_UART1_TX_3V3: U48.27(BDBUS1) U123.15(1B1)
FT4232_USB_DM: J17.2(D-) U46.5(IO2) U48.7(DM)
FT4232_USB_DP: J17.3(D+) U46.3(IO1) U48.8(DP)
FT4232_USB_VBUS: C495.2 C498.2 D7.2 J17.1(VBUS) U46.1(VCC) U121.4(EN) U121.6(IN)
FT4232_WKUP_UART0_CTS_3V3: U48.40(CDBUS2) U118.12(2B2)
FT4232_WKUP_UART0_RTS_3V3: U48.41(CDBUS3) U118.14(1B2)
FT4232_WKUP_UART0_RX_3V3: U48.38(CDBUS0) U118.13(2B1)
FT4232_WKUP_UART0_TX_3V3: U48.39(CDBUS1) U118.15(1B1)
FT_PWREN#: R228.1 U48.60(P\W\R\E\N\)
GPIO1_23_INTN: R448.1 R512.2 U18.C15(UART0_RTSN)
GPIO2_BUF_EN: R491.2 R494.1 U102.5(OE)
GPIO_AUD_RSTN: R427.1 R432.2 U92.9(P10) U93.1(A)
GPIO_CPSW1_RST: R174.1 R175.1 U41.1(A) U92.2(P01)
GPIO_CPSW2_RST: R180.1 R181.1 U2.19(P22) U42.1(A)
GPIO_EMMC_RSTN: R136.1 U32.1(A) U92.10(P11)
GPIO_HDMI_RSTN: R438.1 R442.2 U92.13(P14) U94.1(A)
GPIO_MCU_SOC: R512.1 R572.1 U108.5(2Y)
GPIO_MCU_SOC_INTN: R572.2 R573.1 U18.B9(MCU_MCAN1_RX)
GPIO_OSPI_RSTN: R41.1 U11.1(A) U18.G19(OSPI0_CSN1)
HB_LM5141: C412.2 D9.1(CATHODE) U89.11(HB)
HDMI_AUDD1: TP10.1(TP) U13.40(SD1)
HDMI_AUDD2: TP12.1(TP) U13.39(SD2)
HDMI_AUDD3: TP14.1(TP) U13.37(SD3)
HDMI_CEC: U13.71(CEC_A) U58.1(CEC_A)
HDMI_CEC_D: TP11.1(TP) U13.50(CEC_D)
HDMI_CLK+: J5.10 U13.59(TXC+) U58.16(CLK+)
HDMI_CLK-: J5.12 U13.58(TXC-) U58.15(CLK-)
HDMI_CONN_I2CSCL: J5.15 U58.8(SCL_B)
HDMI_CONN_I2CSDA: J5.16 U58.9(SDA_B)
HDMI_CONNCEC: J5.13 U58.7(CEC_B)
HDMI_EARTH: FL2.2 J5.20 J5.21 J5.22 J5.23
HDMI_EXTSWING: R308.1 U13.56(EXT_SWING)
HDMI_HPD: R47.1 U13.54(HPD) U58.4(HPD_A)
HDMI_I2C_SCL: R298.2 U13.49(DSCL) U58.2(SCL_A)
HDMI_I2C_SDA: R310.2 U13.48(DSDA) U58.3(SDA_A)
HDMI_INTN: R45.2 U13.52(INT) U92.17(P20)
HDMI_MSTRCLK: R43.2 U13.38(MCLK)
HDMI_PCLK: R318.2 U13.22(IDCK)
HDMI_RSTN: R463.2 U13.51(RESET#) U94.4(Y)
HDMI_TX0+: J5.7 U13.62(TX0+) U58.18(D0+)
HDMI_TX0-: J5.9 U13.61(TX0-) U58.17(D0-)
HDMI_TX1+: J5.4 U13.65(TX1+) U58.21(D1+)
HDMI_TX1-: J5.6 U13.64(TX1-) U58.20(D1-)
HDMI_TX2+: J5.1 U13.68(TX2+) U58.23(D2+)
HDMI_TX2-: J5.3 U13.67(TX2-) U58.22(D2-)
HDMICONN_HPD: J5.19 U58.10(HPD_B)
HFOSC0_CLKOUT_32K: R282.1 U18.B10(WKUP_CLKOUT0)
HO_LM5141: R420.1 U89.13(HO)
HOL_LM5141: R420.2 U39.4(GATE) U89.14(HOL)
HPLOUT: C430.2 J14.2
HPLOUT_C: C430.1 U88.18(HPLOUT)
HPROUT: C431.2 J14.3
HPROUT_C: C431.1 U88.23(HPROUT)
INA_ALERT: R67.2 R68.1 R109.2 R377.2 R385.2 R386.2 R387.2 TP38.1(TP)
IO_EXP1_INTN: R3.1 U2.32(I\N\T\)
IO_EXP_ADDR: R489.1 U100.26(ADDR)
IO_EXP_INTN: R448.2 R451.1 U92.32(I\N\T\)
IO_EXP_TEST_LED: R163.1 R164.2 U92.24(P27)
JTAG_CTI_RTCK: J19.9 R562.1
JTAG_CTI_TCK: J19.11 R504.1 R519.1 U107.1(B) U117.1(B)
JTAG_DIR: R521.2 U114.4(1DIR) U114.5(2DIR)
JTAG_EMU0: J19.13 R564.2 U106.7(B1)
JTAG_EMU1: J19.14 R566.2 U106.6(B2)
JTAG_EMU_RSTN: J19.15 R552.2 U116.6(C)
JTAG_TCK: R499.1 R528.1 U114.14(1B2)
JTAG_TDI: J19.3 R542.1 U114.12(2B2)
JTAG_TDIS: J19.4 R567.2
JTAG_TDO: J19.7 U122.7(B1)
JTAG_TMS: J19.1 R537.1 U114.13(2B1)
JTAG_TRST#: J19.2 R524.2 U114.15(1B1)
LDO_1V8: C122.1 U90.35(LDO_1V8)
LDO_3V3: C105.1 C121.2 R142.1 R145.1 R146.1 R147.1 R158.1 R161.1 R412.1 R414.1 R415.1 R419.1 R425.1 R428.1 U27.49(FB_B3) U34.8(VCC) U90.9(LDO_3V3)
LINE1L+: C414.1 TP59.1(TP)
LINE1L+_C: C414.2 U88.3(LINE1L+)
LINE1R+: C416.1 TP60.1(TP)
LINE1R+_C: C416.2 U88.5(LINE1R+)
LO_LM5141: R417.1 U89.8(LO)
LOL_LM5141: R418.1 U89.7(LOL)
LPDDR4_CA0: U18.J5(DDR0_A0) U26.H2(CA0_A) U26.R2(CA0_B)
LPDDR4_CA1: U18.J2(DDR0_A1) U26.J2(CA1_A) U26.P2(CA1_B)
LPDDR4_CA2: U18.J4(DDR0_A2) U26.H9(CA2_A) U26.R9(CA2_B)
LPDDR4_CA3: U18.L4(DDR0_A3) U26.H10(CA3_A) U26.R10(CA3_B)
LPDDR4_CA4: U18.J1(DDR0_A4) U26.H11(CA4_A) U26.R11(CA4_B)
LPDDR4_CA5: U18.K5(DDR0_A5) U26.J11(CA5_A) U26.P11(CA5_B)
LPDDR4_CAL0: R349.1 U18.H6(DDR0_CAL0)
LPDDR4_CK_N: U18.L1(DDR0_CK0_N) U26.J9(CK_C_A) U26.P9(CK_C_B)
LPDDR4_CK_P: U18.M1(DDR0_CK0) U26.J8(CK_T_A) U26.P8(CK_T_B)
LPDDR4_CKE0: U18.P3(DDR0_CKE0) U26.J4(CKE0_A) U26.P4(CKE0_B)
LPDDR4_CKE1: U18.P5(DDR0_CKE1) U26.J5(CKE1_A) U26.P5(CKE1_B)
LPDDR4_CS0_A: U18.J6(DDR0_CS0_N) U26.H4(CS0_A)
LPDDR4_CS0_B: U18.M6(DDR0_RAS_N) U26.R4(CS0_B)
LPDDR4_CS1_A: U18.N4(DDR0_CS1_N) U26.H3(CS1_A)
LPDDR4_CS1_B: U18.M5(DDR0_CAS_N) U26.R3(CS1_B)
LPDDR4_DMI0: U18.C2(DDR0_DM0) U26.C3(DMI0_A)
LPDDR4_DMI1: U18.F3(DDR0_DM1) U26.C10(DMI1_A)
LPDDR4_DMI2: U18.U1(DDR0_DM2) U26.Y3(DMI0_B)
LPDDR4_DMI3: U18.W3(DDR0_DM3) U26.Y10(DMI1_B)
LPDDR4_DQ0: U18.A5(DDR0_DQ0) U26.B2(DQ0_A)
LPDDR4_DQ1: U18.B4(DDR0_DQ1) U26.C2(DQ1_A)
LPDDR4_DQ2: U18.B6(DDR0_DQ2) U26.E2(DQ2_A)
LPDDR4_DQ3: U18.D5(DDR0_DQ3) U26.F2(DQ3_A)
LPDDR4_DQ4: U18.C5(DDR0_DQ4) U26.F4(DQ4_A)
LPDDR4_DQ5: U18.C3(DDR0_DQ5) U26.E4(DQ5_A)
LPDDR4_DQ6: U18.B2(DDR0_DQ6) U26.C4(DQ6_A)
LPDDR4_DQ7: U18.A3(DDR0_DQ7) U26.B4(DQ7_A)
LPDDR4_DQ8: U18.E2(DDR0_DQ8) U26.B11(DQ8_A)
LPDDR4_DQ9: U18.F5(DDR0_DQ9) U26.C11(DQ9_A)
LPDDR4_DQ10: U18.E6(DDR0_DQ10) U26.E11(DQ10_A)
LPDDR4_DQ11: U18.G2(DDR0_DQ11) U26.F11(DQ11_A)
LPDDR4_DQ12: U18.G6(DDR0_DQ12) U26.F9(DQ12_A)
LPDDR4_DQ13: U18.G4(DDR0_DQ13) U26.E9(DQ13_A)
LPDDR4_DQ14: U18.E4(DDR0_DQ14) U26.C9(DQ14_A)
LPDDR4_DQ15: U18.D3(DDR0_DQ15) U26.B9(DQ15_A)
LPDDR4_DQ16: U18.T6(DDR0_DQ16) U26.AA2(DQ0_B)
LPDDR4_DQ17: U18.T4(DDR0_DQ17) U26.Y2(DQ1_B)
LPDDR4_DQ18: U18.U5(DDR0_DQ18) U26.V2(DQ2_B)
LPDDR4_DQ19: U18.R5(DDR0_DQ19) U26.U2(DQ3_B)
LPDDR4_DQ20: U18.P2(DDR0_DQ20) U26.U4(DQ4_B)
LPDDR4_DQ21: U18.R3(DDR0_DQ21) U26.V4(DQ5_B)
LPDDR4_DQ22: U18.T2(DDR0_DQ22) U26.Y4(DQ6_B)
LPDDR4_DQ23: U18.U3(DDR0_DQ23) U26.AA4(DQ7_B)
LPDDR4_DQ24: U18.Y2(DDR0_DQ24) U26.AA11(DQ8_B)
LPDDR4_DQ25: U18.V2(DDR0_DQ25) U26.Y11(DQ9_B)
LPDDR4_DQ26: U18.V4(DDR0_DQ26) U26.V11(DQ10_B)
LPDDR4_DQ27: U18.W5(DDR0_DQ27) U26.U11(DQ11_B)
LPDDR4_DQ28: U18.Y4(DDR0_DQ28) U26.U9(DQ12_B)
LPDDR4_DQ29: U18.AA3(DDR0_DQ29) U26.V9(DQ13_B)
LPDDR4_DQ30: U18.AA5(DDR0_DQ30) U26.Y9(DQ14_B)
LPDDR4_DQ31: U18.AB4(DDR0_DQ31) U26.AA9(DQ15_B)
LPDDR4_DQS0_N: U18.C1(DDR0_DQS0_N) U26.E3(DQS0_C_A)
LPDDR4_DQS0_P: U18.D1(DDR0_DQS0) U26.D3(DQS0_T_A)
LPDDR4_DQS1_N: U18.F1(DDR0_DQS1_N) U26.E10(DQS1_C_A)
LPDDR4_DQS1_P: U18.G1(DDR0_DQS1) U26.D10(DQS1_T_A)
LPDDR4_DQS2_N: U18.P1(DDR0_DQS2_N) U26.V3(DQS0_C_B)
LPDDR4_DQS2_P: U18.R1(DDR0_DQS2) U26.W3(DQS0_T_B)
LPDDR4_DQS3_N: U18.Y1(DDR0_DQS3_N) U26.V10(DQS1_C_B)
LPDDR4_DQS3_P: U18.W1(DDR0_DQS3) U26.W10(DQS1_T_B)
LPDDR4_ODT_CA_A: R370.1 U26.G2(ODT_CA_A)
LPDDR4_ODT_CA_B: R369.1 U26.T2(ODT_CA_B)
LPDDR4_RESET_N: R350.2 R352.1 U18.P6(DDR0_RESET0_N) U26.T11(RESET_N)
LPDDR4_ZQ0: R122.2 U26.A5(ZQ0)
LPDDR4_ZQ1: R119.2 U26.A8(ZQ1)
M2_LED1#: J2.6(LED_1#) TP95.1(TP)
M2_LED2#: J2.16(LED_2#) TP92.1(TP)
MCASP1_ACLKX_AUD: TP56.1(TP) U52.3(1B2) U88.38(BCLK)
MCASP1_ACLKX_BT: J2.8(PCM_CLK/I2S_SCK) U51.5(A4)
MCASP1_ACLKX_BUF: U18.L19(GPMC0_BE0N_CLE) U51.7(B4) U52.4(1A)
MCASP1_ACLKX_HDMI: U13.45(SCK) U52.2(1B1)
MCASP1_AFSX_AUD: TP52.1(TP) U52.6(2B2) U88.39(WCLK)
MCASP1_AFSX_BT: J2.10(PCM_SYNC/I2S_WS) U51.4(A3)
MCASP1_AFSX_BUF: U18.R18(GPMC0_WAIT0) U51.8(B3) U52.7(2A)
MCASP1_AFSX_HDMI: U13.44(WS) U52.5(2B1)
MCASP1_AXR0_AUD: TP57.1(TP) U52.10(3B2) U88.40(DIN)
MCASP1_AXR0_BT: J2.12(PCM_IN/I2S_SD_IN) R256.2 U51.3(A2)
MCASP1_AXR0_BUF: U18.K19(GPMC0_WEN) U51.9(B2) U52.9(3A)
MCASP1_AXR0_HDMI: U13.41(SD0) U52.11(3B1)
MCASP1_AXR2: R51.2 R52.2 U18.L18(GPMC0_ADVN_ALE)
MCASP1_AXR2_AUD: R404.1 TP51.1(TP) U52.13(4B2)
MCASP1_AXR2_BT: J2.14(PCM_OUT/I2S_SD_OUT) U51.2(A1)
MCASP1_AXR2_BUF: R51.1 U51.10(B1) U52.12(4A)
MCASP1_BUF_BT_EN: R19.1 U92.20(P23)
MCASP1_BUF_BT_EN_1V8: R18.2 R19.2 U51.12(OE)
MCASP1_FET_EN: R252.1 R253.2 U52.15(O\E\) U92.19(P22)
MCASP1_FET_SEL: J12.1 R168.1 U52.1(S) U92.21(P24)
MCU_GPIO0_15: J8.10 R89.2
MCU_GPIO0_15_R: R88.2 R89.1 U18.D7(MCU_MCAN1_TX)
MCU_GPIO0_16: J8.11 R573.2
MCU_I2C0_SCL: J8.24 R388.2 U18.E12(MCU_I2C0_SCL) U27.32(GPIO1)
MCU_I2C0_SDA: J8.21 R137.2 R391.2 U18.D9(MCU_I2C0_SDA) U27.33(GPIO2)
MCU_INTN: R123.1 U18.E11(MCU_SPI0_CS0)
MCU_MCAN0_RX: J8.22 U18.E8(MCU_MCAN0_RX)
MCU_MCAN0_TX: J8.16 U18.C7(MCU_MCAN0_TX)
MCU_OSC0_XI: R69.2 R71.2 U18.A12(MCU_OSC0_XI)
MCU_OSC0_XO: R74.2 R77.2 U18.A11(MCU_OSC0_XO)
MCU_PORZ: R184.1 R454.2 TP69.1(TP) U18.A7(MCU_PORZ) U96.4(Y)
MCU_RESETSTATZ: J8.23 TP45.1(TP) U18.D14(MCU_RESETSTATZ)
MCU_RESETZ: R505.2 TP80.1(TP) U18.C12(MCU_RESETZ) U108.7(1Y)
MCU_SAFETY_ERRORZ_1V8: TP9.1(TP) U10.3(A2) U18.B8(MCU_ERRORN)
MCU_SAFETY_ERRORZ_3V3: J8.26 U10.6(B2) U27.18(GPIO7)
MCU_SPI0_CLK: J8.18 U18.B13(MCU_SPI0_CLK)
MCU_SPI0_CS1: J8.8 R580.1
MCU_SPI0_CS1_R: R580.2 U18.C11(MCU_SPI0_CS1)
MCU_SPI0_D0: J8.6 U18.A15(MCU_SPI0_D0)
MCU_SPI0_D1: J8.4 U18.B12(MCU_SPI0_D1)
MCU_UART0_CTS: U18.B11(MCU_UART0_CTSN) U33.9(3A)
MCU_UART0_CTS_3V3: U33.11(3B1) U110.9(2A2)
MCU_UART0_CTS_CONN: J8.12 U33.10(3B2)
MCU_UART0_MUX_OE: R141.1 U33.15(O\E\)
MCU_UART0_MUX_SEL: J10.2 R144.2 U33.1(S)
MCU_UART0_RTS: U18.D10(MCU_UART0_RTSN) U33.12(4A)
MCU_UART0_RTS_3V3: U33.14(4B1) U110.7(1A2)
MCU_UART0_RTS_CONN: J8.17 U33.13(4B2)
MCU_UART0_RX_3V3: U33.2(1B1) U110.8(2A1)
MCU_UART0_RXD: U18.D8(MCU_UART0_RXD) U33.4(1A)
MCU_UART0_RXD_CONN: J8.13 U33.3(1B2)
MCU_UART0_TX_3V3: R523.2 U33.5(2B1) U110.6(1A1)
MCU_UART0_TXD: U18.F8(MCU_UART0_TXD) U33.7(2A)
MCU_UART0_TXD_CONN: J8.19 U33.6(2B2)
MFP0: R152.1 R403.2 U88.45(MFP0)
MFP1: R153.1 R402.2 U88.46(MFP1)
MFP2: TP55.1(TP) U88.47(MFP2)
MFP3: TP54.1(TP) U88.48(MFP3)
MIC_IN: C426.1 J14.1 R437.1 U88.12(MICDET)
MMC0_CLK: R343.1 R371.1 R373.2 U28.M6(CLK)
MMC1_CLK: J22.5(CLK) R98.1 R315.1 R321.1 U22.6(IO4)
MMC1_CLK_R: R321.2 U18.E22(MMC1_CLK)
MMC1_CMD: J22.3(CMD) R90.1 U18.C21(MMC1_CMD) U22.1(IO1)
MMC1_D0: J22.7(DAT0) R100.1 U18.B22(MMC1_DAT0) U22.8(IO6)
MMC1_D1: J22.8(DAT1) R99.1 U18.D21(MMC1_DAT1) U22.7(IO5)
MMC1_D2: J22.1(DAT2) R91.1 U18.C22(MMC1_DAT2) U22.2(IO2)
MMC1_D3: J22.2(CD/DAT3) R92.1 U18.D22(MMC1_DAT3) U22.3(IO3)
MMC1_SD_EN: R106.1 U92.4(P03)
MMC1_SD_LS_EN: R79.1 R105.2 U20.3(ON) U24.4(Y)
MMC1_SDCARD_EN: R105.1 R374.1
MMC1_SDCD: J22.9(CD) R97.1 U18.E18(MMC1_SDCD) U79.5(IO2)
MMC2_CLK: R241.1 R242.1 R243.2 R244.1 R316.2
MMC2_CMD: R259.2 R267.2 R275.1 U18.G22(MMC2_CMD)
MMC2_D0: R261.2 R269.2 R277.1 U18.E20(MMC2_DAT0)
MMC2_D1: R260.2 R268.2 R276.1 U18.F21(MMC2_DAT1)
MMC2_D2: R258.2 R266.2 R274.1 U18.F20(MMC2_DAT2)
MMC2_D3: R257.2 R265.2 R273.1 U18.G21(MMC2_DAT3)
OSC0: C146.2 U47.88(OSC0) Y4.3
OSC1: C145.2 U47.89(OSC1) Y4.1
OSPI0_CSN0: R320.2 U18.H21(OSPI0_CSN0)
OSPI0_LBCLK: R312.2 R319.1
OSPI0_LBCLKO_R: R319.2 U18.K22(OSPI0_LBCLKO)
OSPI_CLK: R311.1 R313.1 U18.L22(OSPI0_CLK)
OSPI_CS: R304.1 R320.1 U12.C2(C\S\)
OSPI_DQ0: R299.1 RA1.2 U12.D3(IO0)
OSPI_DQ1: R302.1 RA2.1 U12.D2(IO1)
OSPI_DQ2: R303.1 RA2.2 U12.C4(IO2/W\P\)
OSPI_DQ3: R300.1 RA1.3 U12.D4(IO3)
OSPI_DQ4: R301.1 RA2.4 U12.D5(IO4)
OSPI_DQ5: R297.1 RA1.4 U12.E3(IO5)
OSPI_DQ6: R296.1 RA2.3 U12.E2(IO6)
OSPI_DQ7: R295.1 RA1.1 U12.E1(IO7)
OSPI_DQS: R305.1 R306.1 R309.1 U12.C3(DS)
OSPI_DQS_SOC: R309.2 R312.1 U18.L21(OSPI0_DQS)
OSPI_INTN: R49.1 R50.1 U18.K20(OSPI0_CSN2)
OSPI_RSTN: R46.1 U11.4(Y) U12.A4(R\E\S\E\T\)
P2_PP_EXT_ENABLE: R449.1 U90.49(GPIO17/PP_EXT2)
PD_GPIO0: R416.2 U90.16(GPIO0)
PD_GPIO2: TP58.1(TP) U90.18(GPIO2)
PD_HRESET: R445.1 U90.44(HRESET)
PD_I2C_IRQ: R167.2 R169.1 U92.23(P26)
PD_M_I2C3_IRQ: R412.2 U90.23(I\2\C\3\_\I\R\Q\/GPIO7)
PD_M_I2C3_SCL: R161.2 R395.1 U90.21(I2C3_SCL/GPIO5)
PD_M_I2C3_SDA: R158.2 R396.1 U90.22(I2C3_SDA/GPIO6)
PD_MS_I2C1_IRQ: R419.2 U90.29(I\2\C\1\_\I\R\Q\)
PD_MS_I2C1_SCL: R393.1 R415.2 U90.27(I2C1_SCL)
PD_MS_I2C1_SDA: R394.1 R414.2 U90.28(I2C1_SDA)
PD_S_I2C2_IRQ: R169.2 U90.34(I\2\C\2\_\I\R\Q\)
PD_S_I2C2_SCL: R421.2 U90.32(I2C2_SCL)
PD_S_I2C2_SDA: R422.2 U90.33(I2C2_SDA)
PD_SPI_CLK: J11.7 R436.2 U34.6(CLK)
PD_SPI_MISO: J11.5 R146.2 R426.2 U34.2(DO(IO1))
PD_SPI_MOSI: J11.8 R431.2 U34.5(DI(IO0))
PD_SPI_SS: J11.9 R147.2 R439.2 U34.1(C\S\)
PD_VIN_3V3: C123.2 U90.5(VIN_3V3)
PMIC_AMUXOUT: TP36.1(TP) U27.1(AMUXOUT)
PMIC_ENABLE: TP42.1(TP) U31.4(A) U36.1(A)
PMIC_ENABLE_SEL: J9.1 R138.1 U31.1(SEL)
PMIC_INT_B: R123.2 R126.1 R127.2 TP33.1(TP) U27.14(NINT)
PMIC_INTN: R53.2 R127.1 U18.F17(EXTINTN)
PMIC_LPM_EN0: R140.1 TP41.1(TP) U18.D12(PMIC_LPM_EN0) U31.3(A1) U31.8(B0)
PMIC_NPWRON/ENABLE: R148.2 U27.20(NPWRON/ENABLE)
PMIC_NSLEEP: U27.46(GPIO3) U31.6(B)
PMIC_OSC32KCAP: C381.1 U27.40(OSC32KCAP)
PMIC_OSC32KIN: C85.2 U27.38(OSC32KIN) Y3.2
PMIC_OSC32KOUT: C89.2 U27.39(OSC32KOUT) Y3.1
PMIC_POWERGOOD: R500.1 R501.1 TP81.1(TP) U27.25(NRSTOUT) U116.1(A)
PMIC_WDOG_DISABLE: R492.1 R493.2 TP74.1(TP) U27.41(GPIO8)
PMIC_WDOG_TRIGG: R137.1 U18.D13(WKUP_I2C0_SCL)
PORZ_OUT: R104.1 R170.2 TP63.1(TP) U18.F18(PORZ_OUT) U24.6(C) U41.3(B) U42.3(B)
PP1_CABLE: C117.1 U90.25(PP1_CABLE)
PP2_CABLE: R447.2 U90.46(PP2_CABLE)
PR0_PRU0_GPO0: RA5.8 U18.N21(GPMC0_AD0)
PR0_PRU0_GPO1: RA5.7 U18.N20(GPMC0_AD1)
PR0_PRU0_GPO2: RA5.6 U18.N19(GPMC0_AD2)
PR0_PRU0_GPO3: RA5.5 U18.N18(GPMC0_AD3)
PR0_PRU0_GPO4: RA6.5 U18.N17(GPMC0_AD4)
PR0_PRU0_GPO5: RA6.6 U18.P18(GPMC0_AD5)
PR0_PRU0_GPO6: RA6.7 U18.P19(GPMC0_AD6)
PR0_PRU0_GPO7: RA6.8 U18.P21(GPMC0_AD7)
REFCLK1_R: R55.2 U18.A20(MCASP0_AFSX)
RES_LM5141: C427.1 U89.24(RES)
RESETSTATZ: R171.2 R173.1 R178.1 R430.1 TP65.1(TP) U2.28(R\E\S\E\T\) U5.3(R\E\S\E\T\) U11.2(B) U18.F19(RESETSTATZ) U24.3(B) U32.2(B) U92.28(R\E\S\E\T\) U93.2(B) U94.2(B)
RT_LM5141: R423.1 U89.4(RT)
SCL_XDS_TA: R503.2 R612.2 R614.2 U87.7(SCLB)
SDA_XDS_TA: R502.2 R613.2 R615.2 U87.6(SDAB)
SEL_XDS: U103.4(Y) U106.5(OE) U109.4(O\E\) U111.1(1\O\E\) U111.16(2\O\E\)
SEL_XDS110_INV: J19.8 R497.2 R498.1 U103.2(A) U107.2(A) U112.5(OE) U114.1(1\O\E\) U114.16(2\O\E\) U117.2(A) U122.4(O\E\)
SLOW_CLK: J2.50(SUSCLK_32KHZ) R280.2 R282.2
SOC_CLKIN: C19.1 R35.2 R36.2 R69.1
SOC_DVDD1V8: C32.1 C217.1 C218.1 C221.1 C225.1 C258.1 C279.1 C284.1 C528.1(INPUT) C528.3(OUTPUT) C529.1(INPUT) C529.3(OUTPUT) FL12.1 R120.3 U18.F12(VMON_1P8_SOC) U18.H16(VDDSHV6#H16) U18.H17(VDDSHV6#H17) U18.K15(VDDSHV1#K15) U18.L16(VDDSHV1#L16) U18.T8(VDDSHV4#T8) U18.U8(VDDSHV4#U8) U27.37(FB_B5)
SOC_DVDD3V3: C41.1 C229.1 C232.1 C233.1 C238.1 C239.1 C240.1 C244.1 C247.1 C257.1 C270.1 C276.1 C522.1(INPUT) C522.3(OUTPUT) C523.1(INPUT) C523.3(OUTPUT) R94.3 U18.F9(VMON_3P3_SOC) U18.G11(VDDSHV_MCU#G11) U18.G14(VDDSHV0#G14) U18.H10(VDDSHV_MCU#H10) U18.H13(VDDSHV0#H13) U18.L15(VDDSHV3#L15) U18.M15(VDDSHV3#M15) U18.N15(VDDSHV3#N15) U18.R13(VDDSHV2#R13) U18.T13(VDDSHV2#T13) U18.U10(VDDA_3P3_USB) U18.U13(VDDSHV2#U13)
SOC_EMU0: R224.2 U18.C13(EMU0) U106.2(A1) U112.2(A1)
SOC_EMU1: R223.2 U18.E10(EMU1) U106.3(A2) U112.3(A2)
SOC_GPIO1_49: R323.1 R324.2 U18.D18(MMC1_SDWP)
SOC_I2C0_SCL: J3.28 R363.1 R408.2 R421.1 U18.D17(I2C0_SCL) U38.6(SCL)
SOC_I2C0_SCL_PMIC: R363.2 TP43.1(TP) U27.31(SCL_I2C1/SCK_SPI)
SOC_I2C0_SDA: J3.27 R362.1 R409.2 R422.1 U18.E16(I2C0_SDA) U38.5(SDA)
SOC_I2C0_SDA_PMIC: R362.2 TP44.1(TP) U27.30(SDA_I2C1/SDI_SPI)
SOC_I2C1_SCL: R406.1 R433.2 TP49.1(TP) U2.29(SCL) U13.1(CSCL) U16.1(SCL) U17.A1(SCL) U17.C3(A1) U18.C17(I2C1_SCL) U25.A1(SCL) U29.1(SCL) U82.A1(SCL) U83.A1(SCL) U83.C3(A1) U84.A1(SCL) U85.A1(SCL) U85.B3(A0) U87.2(SCLA) U92.29(SCL)
SOC_I2C1_SDA: R405.1 R434.2 TP50.1(TP) U2.30(SDA) U13.2(CSDA) U16.6(SDA) U17.A2(SDA) U18.E17(I2C1_SDA) U25.A2(SDA) U29.6(SDA) U82.A2(SDA) U83.A2(SDA) U84.A2(SDA) U85.A2(SDA) U87.3(SDAA) U92.30(SDA)
SOC_I2C1_TA_SCL: R545.1 R612.1
SOC_I2C1_TA_SDA: R550.1 R613.1
SOC_I2C2_SCL: R279.2 U5.12(SCL) U18.M22(GPMC0_CSN2)
SOC_I2C2_SDA: R278.2 U5.13(SDA) U18.M20(GPMC0_CSN3)
SOC_MMC0_CLK: R343.2 U18.AB7(MMC0_CLK)
SOC_MMC0_CMD: R372.2 U18.Y6(MMC0_CMD) U28.M5(CMD)
SOC_MMC0_DAT0: R113.2 U18.AA6(MMC0_DAT0) U28.A3(DAT0)
SOC_MMC0_DAT1: R115.2 U18.AB6(MMC0_DAT1) U28.A4(DAT1)
SOC_MMC0_DAT2: R117.2 U18.Y7(MMC0_DAT2) U28.A5(DAT2)
SOC_MMC0_DAT3: R111.2 U18.AA7(MMC0_DAT3) U28.B2(DAT3)
SOC_MMC0_DAT4: R112.2 U18.Y8(MMC0_DAT4) U28.B3(DAT4)
SOC_MMC0_DAT5: R114.2 U18.W7(MMC0_DAT5) U28.B4(DAT5)
SOC_MMC0_DAT6: R116.2 U18.W9(MMC0_DAT6) U28.B5(DAT6)
SOC_MMC0_DAT7: R118.2 U18.AB8(MMC0_DAT7) U28.B6(DAT7)
SOC_MMC2_CLK: R316.1 U18.H22(MMC2_CLK)
SOC_OSPI_DQ0: RA1.7 U18.J21(OSPI0_D0)
SOC_OSPI_DQ1: RA2.8 U18.J18(OSPI0_D1)
SOC_OSPI_DQ2: RA2.7 U18.J19(OSPI0_D2)
SOC_OSPI_DQ3: RA1.6 U18.H18(OSPI0_D3)
SOC_OSPI_DQ4: RA2.5 U18.K21(OSPI0_D4)
SOC_OSPI_DQ5: RA1.5 U18.H19(OSPI0_D5)
SOC_OSPI_DQ6: RA2.6 U18.J20(OSPI0_D6)
SOC_OSPI_DQ7: RA1.8 U18.J22(OSPI0_D7)
SOC_PORZ: R544.2 U96.3(B) U116.4(Y)
SOC_RGMII_MDC: R108.1 R606.1 U18.V12(MDIO0_MDC)
SOC_RGMII_MDIO: R107.1 R608.1 U18.V13(MDIO0_MDIO)
SOC_SPI0_CLK: U18.A17(SPI0_CLK) U55.4(1A)
SOC_SPI0_CS0: U18.D16(SPI0_CS0) U55.9(3A)
SOC_SPI0_D0: U18.B15(SPI0_D0) U55.7(2A)
SOC_SPI2_CLK: U18.A21(MCASP0_ACLKR) U54.8(2A1) U95.7(2A)
SOC_SPI2_CS0: U18.B21(MCASP0_AFSR) U54.6(1A1) U95.4(1A)
SOC_SPI2_D0: U18.C19(MCASP0_AXR3) U54.7(1A2) U95.9(3A)
SOC_SPI2_D1: U18.B19(MCASP0_AXR2) U54.9(2A2) U95.12(4A)
SOC_TCK: R515.1 R529.1 U18.A14(TCK)
SOC_TDI: U18.A16(TDI) U111.6(1A1) U114.9(2A2)
SOC_TDO: R326.1 U109.2(A1) U122.2(A1)
SOC_TDO_R: R326.2 U18.C14(TDO)
SOC_TMS: U18.B14(TMS) U111.8(2A1) U114.8(2A1)
SOC_TRST#: R526.1 U18.F15(TRSTN) U111.9(2A2) U114.6(1A1)
SOC_UART0_RX_3V3: U18.E14(UART0_RXD) U119.8(2A1)
SOC_UART0_TX_3V3: R558.2 U18.D15(UART0_TXD) U119.6(1A1)
SOC_UART1_CTS: TP91.1(TP) U95.10(3B2) U123.9(2A2)
SOC_UART1_CTS_BT: J2.34(UART_CTS) U54.14(1B2)
SOC_UART1_RTS: TP90.1(TP) U95.13(4B2) U123.7(1A2)
SOC_UART1_RTS_BT: J2.36(UART_RTS) U54.12(2B2)
SOC_UART1_RX_BT: J2.22(UART_RXD) U54.15(1B1)
SOC_UART1_RXD: TP72.1(TP) U95.3(1B2) U123.8(2A1)
SOC_UART1_TX_BT: R254.2 U54.13(2B1)
SOC_UART1_TXD: R570.2 TP71.1(TP) U95.6(2B2) U123.6(1A1)
SOC_USB0_DM: L7.4(OUT2) U18.AA10(USB0_DM)
SOC_USB0_DP: L7.1(IN1) U18.AA9(USB0_DP)
SOC_USB0_DRVVBUS: R416.1 R446.1 U18.C20(USB0_DRVVBUS)
SOC_USB0_RCALIB: R331.1 U18.W10(USB0_RCALIB)
SOC_USB0_VBUS: R134.1 R338.1 U18.V8(USB0_VBUS)
SOC_USB1_DM: L4.1(IN1) U18.Y11(USB1_DM)
SOC_USB1_DP: L4.4(OUT2) U18.Y10(USB1_DP)
SOC_USB1_DRVVBUS: R128.2 R130.1 U18.D19(USB1_DRVVBUS)
SOC_USB1_RCALIB: R344.1 U18.U7(USB1_RCALIB)
SOC_USB1_VBUS: R124.1 R345.1 U18.V6(USB1_VBUS)
SOC_VDDSHV5_SDIO: C224.1 C226.1 R61.2 U18.G16(VDDSHV5#G16) U18.H15(VDDSHV5#H15)
SOC_VOUT0_DATA0: U13.32(D0) U18.U22(VOUT0_DATA0)
SOC_VOUT0_DATA1: U13.31(D1) U18.U21(VOUT0_DATA1)
SOC_VOUT0_DATA2: U13.30(D2) U18.U20(VOUT0_DATA2)
SOC_VOUT0_DATA3: U13.29(D3) U18.U19(VOUT0_DATA3)
SOC_VOUT0_DATA4: U13.28(D4) U18.T19(VOUT0_DATA4)
SOC_VOUT0_DATA5: U13.27(D5) U18.U18(VOUT0_DATA5)
SOC_VOUT0_DATA6: U13.25(D6) U18.V22(VOUT0_DATA6)
SOC_VOUT0_DATA7: U13.24(D7) U18.V21(VOUT0_DATA7)
SOC_VOUT0_DATA8: U13.23(D8) U18.V19(VOUT0_DATA8)
SOC_VOUT0_DATA9: U13.20(D9) U18.V18(VOUT0_DATA9)
SOC_VOUT0_DATA10: U13.19(D10) U18.W22(VOUT0_DATA10)
SOC_VOUT0_DATA11: U13.18(D11) U18.W21(VOUT0_DATA11)
SOC_VOUT0_DATA12: U13.17(D12) U18.W20(VOUT0_DATA12)
SOC_VOUT0_DATA13: U13.16(D13) U18.W19(VOUT0_DATA13)
SOC_VOUT0_DATA14: U13.15(D14) U18.Y21(VOUT0_DATA14)
SOC_VOUT0_DATA15: U13.14(D15) U18.Y22(VOUT0_DATA15)
SOC_VOUT0_DATA16: RA3.8 U13.13(D16) U18.P22(GPMC0_AD8)
SOC_VOUT0_DATA17: RA3.7 U13.11(D17) U18.R19(GPMC0_AD9)
SOC_VOUT0_DATA18: RA3.6 U13.10(D18) U18.R20(GPMC0_AD10)
SOC_VOUT0_DATA19: RA3.5 U13.9(D19) U18.R22(GPMC0_AD11)
SOC_VOUT0_DATA20: RA4.8 U13.8(D20) U18.T22(GPMC0_AD12)
SOC_VOUT0_DATA21: RA4.7 U13.7(D21) U18.R21(GPMC0_AD13)
SOC_VOUT0_DATA22: RA4.6 U13.6(D22) U18.T20(GPMC0_AD14)
SOC_VOUT0_DATA23: RA4.5 U13.4(D23) U18.T21(GPMC0_AD15)
SOC_VOUT0_DE: U13.33(DE) U18.U17(VOUT0_DE)
SOC_VOUT0_HSYNC: U13.34(HSYNC) U18.T18(VOUT0_HSYNC)
SOC_VOUT0_PCLK: R318.1 U18.AA22(VOUT0_PCLK)
SOC_VOUT0_VSYNC: U13.35(VSYNC) U18.V17(VOUT0_VSYNC)
SOC_WARM_RESETZ: R534.1 TP87.1(TP) U18.E19(RESET_REQZ) U108.2(3Y)
SOC_WLAN_SDIO_RST: U1.13(B1) U2.24(P27)
SPI0_FET_OE: R284.2 U2.18(P21) U55.15(O\E\)
SPI0_FET_SEL: R13.1 R14.2 U2.17(P20) U55.1(S)
SPI_HOLDN: R145.2 U34.7(H\O\L\D\(IO3))
SPI_WPN: R142.2 U34.3(W\P\(IO2))
SS_LM5141: C429.1 U89.22(SS)
SW_2V5: L9.1 U81.5(SW)
SW_LM5141: C412.1 L10.1 Q2.5(D) U39.1(S1) U39.2(S2) U39.3(S3) U89.12(SW)
SYS_BOOTMODE0: R455.1 SW2.1 U100.1(P00) U101.10(A8)
SYS_BOOTMODE1: R456.1 SW2.2 U100.2(P01) U101.9(A7)
SYS_BOOTMODE2: R457.1 SW2.3 U100.3(P02) U101.8(A6)
SYS_BOOTMODE3: R458.1 SW2.4 U100.4(P03) U101.7(A5)
SYS_BOOTMODE4: R459.1 SW2.5 U100.5(P04) U101.6(A4)
SYS_BOOTMODE5: R460.1 SW2.6 U100.6(P05) U101.5(A3)
SYS_BOOTMODE6: R461.1 SW2.7 U100.7(P06) U101.4(A2)
SYS_BOOTMODE7: R462.1 SW2.8 U100.8(P07) U101.3(A1)
SYS_BOOTMODE8: R192.1 SW3.1 U98.10(A8) U100.9(P10)
SYS_BOOTMODE9: R191.1 SW3.2 U98.9(A7) U100.10(P11)
SYS_BOOTMODE10: R190.1 SW3.3 U98.8(A6) U100.11(P12)
SYS_BOOTMODE11: R189.1 SW3.4 U98.7(A5) U100.12(P13)
SYS_BOOTMODE12: R188.1 SW3.5 U98.6(A4) U100.13(P14)
SYS_BOOTMODE13: R187.1 SW3.6 U98.5(A3) U100.14(P15)
SYS_BOOTMODE14: R186.1 SW3.7 U98.4(A2) U100.15(P16)
SYS_BOOTMODE15: R185.1 SW3.8 U98.3(A1) U100.16(P17)
SYSBOOT_BUF_ENZ: R170.1 R171.1 U45.1(A)
TCA6424_EXP_INT: R490.1 U100.32(I\N\T\)
TEMP_DIODE_P: TP99.1(TP) U18.F10(RSVD4)
TEST_GPIO1: Q13.1(G) R484.1 R548.1 R556.1
TEST_GPIO2: R481.1 R531.1 R533.1 U92.18(P21)
TEST_GPIO3: J16.1 R483.1 R486.1 R557.1 TP76.1(TP) U45.2(B)
TEST_GPIO4: R482.1 R527.1 R536.1 TP75.1(TP) U100.28(R\E\S\E\T\)
TEST_PORZN: R472.1 R547.1 R555.1 U96.6(C)
TEST_POWERDOWN: R194.1 R201.1 R546.1 R554.1 U36.6(C)
TEST_WARMRESETN: Q14.1(G) R198.1 R530.1 R532.1
TM4C129_TCK: TP85.1(TP) U47.100(PC0/TCK/SWCLK)
TM4C129_TDI: TP83.1(TP) U47.98(PC2/TDI)
TM4C129_TDO: TP82.1(TP) U47.97(PC3/TDO/SWO)
TM4C129_TMS: TP84.1(TP) U47.99(PC1/TMS/SWDIO)
TMP1_ADD0: R64.1 U16.5(ADD0)
TMP1_ADD1: R63.1 U16.3(ADD1)
TMP2_ADD1: R129.1 U29.3(ADD1)
TPS6593_EN: R148.1 U36.4(Y)
UART1_FET_BUF_EN: R263.1 U40.2(A) U54.1(1\O\E\) U54.16(2\O\E\) U92.11(P12)
UART1_FET_BUF_EN_INV: U40.4(Y) U95.15(O\E\)
UART1_FET_SEL: R177.2 R179.1 U92.22(P25) U95.1(S)
UART_SHIELD: J17.6(SH1) J17.7(SH2) J17.8(SH3) J17.9(SH4) R227.2
USB_DM: J2.5(USB_D-) TP97.1(TP)
USB_DP: J2.3(USB_D+) TP98.1(TP)
USB_TYPEA_EARTH: C399.1 J7.SH1 J7.SH2 R389.1
USB_TYPEACONN_DM: J7.2(D-) L4.2(IN2) U30.5(D1)
USB_TYPEACONN_DP: J7.3(D+) L4.3(OUT1) U30.6(D2)
USB_TYPEC1_EARTH: C410.1 J13.SH1 J13.SH2 J13.SH3 J13.SH4 R157.1
USB_TYPEC2_EARTH: C440.1 J15.SH1 J15.SH2 J15.SH3 J15.SH4 R193.1
USBC_CONN1_CC1: C113.1 D4.1(CATHODE) J13.A5(CC1) U90.24(C1_CC1)
USBC_CONN1_CC2: C116.1 D10.1(CATHODE) J13.B5(CC2) U90.26(C1_CC2)
USBC_CONN2_CC1: C131.1 D5.1(CATHODE) J15.A5(CC1) U90.45(C2_CC1)
USBC_CONN2_CC2: C130.1 D11.1(CATHODE) J15.B5(CC2) U90.47(C2_CC2)
USBC_CONN2_DM: D6.3(IO2) J15.A7(D-_1) J15.B7(D-_2) L7.3(OUT1)
USBC_CONN2_DP: D6.2(IO1) J15.A6(D+_1) J15.B6(D+_2) L7.2(IN2)
VHDMI_AVCC_1V2: C203.1 C205.1 C207.1 FB2.1 U13.60(AVCC12_1) U13.66(AVCC12_2)
VHDMI_CVCC_1V2: C196.1 C200.1 C201.1 C206.1 C208.1 C212.1 FB1.1 U13.5(CVCC12_1) U13.12(CVCC12_2) U13.26(CVCC12_3) U13.42(CVCC12_4) U13.47(CVCC12_5) U13.53(CVCC12_6)
VHDMI_IOVCC_3V3: C197.1 C210.1 C211.1 FB3.1 R45.1 R57.1 R298.1 R310.1 U13.3(IOVCC1) U13.21(IOVCC2) U13.46(IOVCC3)
VLDO_CSI_1V8: R248.1 U50.5(OUT2)
VLDO_CSI_3V3: R247.1 U50.6(OUT1)
VMAIN: C114.1 C120.1 C128.1 C129.1 C132.1 C140.1 C141.1 C420.1 C448.1 C505.1 R199.1 R444.2 R569.1 TP68.1(TP) U39.5(D1) U43.12(VIN) U89.15(VIN) U90.1(PP_HV2) U90.11(PP_HV1) U120.2(VIN)
VPHY_3V3_FT4232: C486.2 FL14.1 U48.4(VPHY)
VPLL_3V3_FT4232: C494.2 FL15.1 R235.2 U48.9(VPLL)
VPP_1V8: C81.1 C288.1 C290.1 C291.1 TP35.1(TP) U18.F7(VPP) U27.11(VOUT_LDO2)
VPP_EN: U27.19(GPIO9) U92.5(P04)
VRTC_PMIC_1V8: C86.1 TP37.1(TP) U27.3(VOUT_LDOVRTC)
VSEL_SD_SOC: R87.1 TP19.1(TP) U18.N22(GPMC0_CLK) U27.23(GPIO5)
WKUP_LFOSCO_XI: C45.1 U18.A8(WKUP_LFOSC0_XI) Y2.1
WKUP_LFOSCO_XO: C42.1 U18.A9(WKUP_LFOSC0_XO) Y2.2
WKUP_UART0_CTS_3V3: U18.C10(WKUP_UART0_CTSN) U118.9(2A2)
WKUP_UART0_RTS_3V3: U18.C8(WKUP_UART0_RTSN) U118.7(1A2)
WKUP_UART0_RX_3V3: U18.C9(WKUP_UART0_RXD) U118.8(2A1)
WKUP_UART0_TX_3V3: R535.2 U18.E9(WKUP_UART0_TXD) U118.6(1A1)
WL_LT_EN: R6.1 R7.2 U1.8(OE) U2.9(P10)
WLAN_ALERT_1V8: R8.2 U1.5(A4)
WLAN_ALERTN: R2.1 U1.10(B4) U92.16(P17)
WLAN_EN: R11.1 R12.2 U1.4(A3) U18.F22(MMC2_SDCD)
WLAN_EN_3V3: R10.2 U1.11(B3)
WLAN_IRQ: J2.21(SDIO_WAKE#) R262.1 U18.E21(MMC2_SDWP)
WLAN_SDIO_RST: J2.23(SDIO_RESET#/TX_BLANKING) R9.1 U1.2(A1)
XDS110_DIR: R517.2 U111.4(1DIR) U111.5(2DIR)
XDS110_EMU0: R234.2 U47.42(PF0) U112.7(B1)
XDS110_EMU1: R233.2 U47.43(PF1) U112.6(B2)
XDS110_TCK: U47.35(PA2/SSI0CLK) U111.14(1B2)
XDS110_TDI: U47.38(PA5/SSI0XDAT1) U111.15(1B1)
XDS110_TDO: U47.37(PA4/SSI0XDAT0) U109.7(B1)
XDS110_TMS: U47.36(PA3/SSI0FSS) U111.13(2B1)
XDS110_TRST#: U47.40(PA6) U111.12(2B2)
XDS_GPIO1: R484.2 U44.2(1Y)
XDS_GPIO2: R481.2 U102.7(B1)
XDS_GPIO3: R483.2 U44.4(2Y)
XDS_GPIO4: R482.2 U44.6(3Y)
XDS_PORZN: R472.2 U44.8(4Y)
XDS_POWERDOWN: R194.2 U44.12(6Y)
XDS_RSTN: R506.1 R511.1 TP78.1(TP) U47.70(R\S\T\)
XDS_SHIELD: C159.2 J18.6(SH1) J18.7(SH2) J18.8(SH3) J18.9(SH4) R226.2
XDS_USB_DM: J18.2(D-) U47.93(PL7/USB0DM) U115.5(IO4)
XDS_USB_DP: J18.3(D+) U47.94(PL6/USB0DP) U115.4(IO3)
XDS_USB_ID: J18.4(ID) R204.2 U115.2(IO2)
XDS_USB_VBUS: C155.1 C470.1 D8.2 J18.1(VBUS) R237.1 R496.1 R507.1 TP89.1(TP) U105.1(IN1) U105.2(IN2) U115.6(VCC)
XDS_VREF: C161.1 C165.2 R239.2 U47.9(VREFA+) U49.3(CATHODE)
XDS_WARMRESETN: R198.2 U44.10(5Y)
N15951749: C177.1 R264.2 R272.2 U56.1(TRI-STATE) U56.4(VDD)
N15952254: R280.1 U56.3(OUTPUT)
N16839912: C385.1 R375.1 U82.D3(IN+)
N16839940: C392.1 R378.1 U83.D3(IN+)
N16839975: C394.1 R382.1 U85.D3(IN+)
N16856152: C149.1 U48.3(OSCO) Y5.2
N16856224: C148.1 U48.2(OSCI) Y5.1
N16857368: C504.2 U121.2(NR/FB)
N16878333: R560.2 U119.5(2DIR)
N16878339: R561.1 U119.4(1DIR)
N16878497: R368.1 TP100.1(TP) U28.H5(DS)
N16880083: R106.2 R353.1 U24.1(A)
N16893179: R520.2 U110.5(2DIR)
N16893185: R516.1 U110.4(1DIR)
N16894003: R540.2 U118.5(2DIR)
N16894009: R541.1 U118.4(1DIR)
N16906426: C33.2 R71.1 Y1.1
N16906432: C36.2 R74.1 Y1.3
N16927060: R57.2 U13.72(CI2CA)
N16927228: R54.1 U13.69(IO_SEL)
N16927289: R48.2 U13.36(SPDIF)
N16929458: TP62.1(TP) U88.7(LINE2L+)
N16929460: TP61.1(TP) U88.8(LINE2L-)
N16929474: R404.2 U88.41(DOUT)
N16929699: C115.1 U88.4(LINE1L-)
N16929703: C119.1 U88.6(LINE1R-)
N16929744: TP67.1(TP) U88.19(HPLCOM)
N16929747: TP66.1(TP) U88.22(HPRCOM)
N16929749: TP102.1(TP) U88.35(GPIO1)
N16929751: TP103.1(TP) U88.34(GPIO2)
N16931396: R270.2 U53.B2(CL)
N16931420: R281.1 U53.C1(OC)
N16943223: R33.1 U7.2(1G)
N16947096: R23.1 U6.1(TRI-STATE)
N16960546: R313.2 U12.B2(CLK)
N16990175: J23.27 R555.2
N16990176: J23.30 R556.2
N16990179: J23.31 R533.2
N16990180: J23.32 R557.2
N16990246: J23.26 R554.2
N16990247: J23.28 R532.2
N16990252: J23.33 R536.2
N16994873: R499.2 U107.4(Y)
N16994875: R562.2 U117.4(Y)
N16995245: C474.1 R519.2
N16997746: R232.1 U47.59(RBAIS)
N17030208: R515.2 U111.7(1A2)
N17031262: LD6.2(ANODE) R203.2
N17078351: R209.1 SW2.13
N17078353: R210.1 SW2.14
N17078355: R211.1 SW2.15
N17078357: R212.1 SW2.16
N17078758: R215.1 SW3.11
N17078760: R216.1 SW3.12
N17078762: R217.1 SW3.13
N17078764: R218.1 SW3.14
N17078766: R213.1 SW3.9
N17078768: R214.1 SW3.10
N17078770: R219.1 SW3.15
N17078778: R220.1 SW3.16
N17078974: J16.2 R495.2
N17084256: R205.1 SW2.9
N17084257: R206.1 SW2.10
N17084258: R207.1 SW2.11
N17084259: R208.1 SW2.12
N17110597: TP26.1(TP) U78.13(VDDA1P8#13)
N17133547: FL11.2 J6.2(VCC)
N17137240: J6.11 R330.2
N17153379: R101.3 R102.2
N17153381: R101.2 R103.2
N17153383: C79.2 R110.2 R356.2 R359.2
N17153415: R356.1 R380.2
N17153417: R356.4 R381.2
N17153507: R66.2 R94.1
N17153509: R72.2 R94.4
N17153511: C34.2 R72.1 U17.D1(BUS) U17.D2(IN-)
N17153515: C34.1 R66.1 U17.D3(IN+)
N17153617: R120.1 R375.2
N17153619: R120.4 R376.2
N17153623: R132.1 R378.2
N17153625: R132.4 R379.2
N17153667: R131.3 R382.2
N17153669: R131.2 R383.2
N17153681: C69.1 R102.1 U25.D3(IN+)
N17153685: C69.2 R103.1 U25.D1(BUS) U25.D2(IN-)
N17153701: C393.2 R381.1 U84.D1(BUS) U84.D2(IN-)
N17153703: C393.1 R380.1 U84.D3(IN+)
N17153749: C385.2 R376.1 U82.D1(BUS) U82.D2(IN-)
N17153787: C392.2 R379.1 U83.D1(BUS) U83.D2(IN-)
N17153799: C394.2 R383.1 U85.D1(BUS) U85.D2(IN-)
N17153878: R385.1 U84.A3(ALERT)
N17153949: R377.1 U82.A3(ALERT)
N17153951: R386.1 U83.A3(ALERT)
N17154063: R387.1 U85.A3(ALERT)
N17167245: R348.2 U78.32(RX_CLK)
N17253632: C500.1 L11.2 R563.2 R577.1 U120.10(VOS)
N17253649: L11.1 U120.9(SW)
N17253673: R563.1 TP106.1(TP) U120.7(PG)
N17253694: R569.2 U120.3(EN)
N17269599: R173.2 R176.1 U41.6(C)
N17275147: R407.2 U86.3(OUTPUT)
N17285208: R317.1 U58.5(LS_OE) U58.12(CT_HPD)
N17370891: R413.2 U90.17(GPIO1)
N17378539: LD8.1(CATHODE) R228.2
N17479799: R507.2 U105.8(EN)
N17479805: C458.2 R487.1 R488.2 U105.5(NR/FB)
N17479881: C144.2 R202.1 U47.68(VBAT)
N17481587: LD9.2(ANODE) R236.2
N17481598: C143.2 R496.2 U47.96(PB1/USB0VBUS)
N17481613: R204.1 U47.95(PB0/USB0ID)
N17481619: R237.2 R238.1 U47.1(PD0/AIN15)
N17481621: R231.2 R525.1 U47.60(PK7)
N17481627: R240.1 U47.3(PD2/AIN13)
N17481631: LD10.2(ANODE) R240.2
N17481633: R225.2 R514.1 U47.63(PK4)
N17481635: R230.2 R522.1 U47.61(PK6)
N17481637: R236.1 U47.4(PD3/AIN12)
N17481641: R229.2 R518.1 U47.62(PK5)
N17492093: R40.2 U10.5(OE)
N17492111: J10.1 R392.1
N17498937: R405.2 U88.2(SDA)
N17498940: R406.2 U88.1(SCL)
N17653582: Q5.3(G) R327.2
N17726648: D2.3(C) R134.2 R135.1
N17796705: Q6.3(G) R364.2
N17796716: Q7.3(G) R365.2
N17824845: R426.1 U90.36(SPI_MISO/GPIO8)
N17824852: R431.1 U90.37(SPI_MOSI/GPIO9)
N17824859: R436.1 U90.38(SPI_CLK/GPIO10)
N17824866: R439.1 U90.39(S\P\I\_\S\S\/GPIO11)
N17827086: J11.1 R393.2 R395.2
N17827089: J11.3 R394.2 R396.2
N17849698: C445.1 Q10.1(S1) Q10.2(S2) Q10.5(S3) Q10.6(S4) Q10.8(S5) Q11.1(S1) Q11.2(S2) Q11.5(S3) Q11.6(S4) Q11.8(S5) R475.1
N17850096: C444.2 C445.2 C455.2 Q10.3(G) Q11.3(G) R467.1 R468.2 R475.2 R485.2
N17935978: Q9.3(G) R446.2 R449.2 R453.1
N17936309: Q9.1(D1) Q9.2(D2) Q9.5(D3) Q9.6(D4) Q9.8(D5) R467.2
N18121816: J21.2 R261.1
N18121892: J21.4 R260.1
N18121904: J21.6 R259.1
N18121916: J21.9 R244.2
N18121928: J21.12 R258.1
N18121940: J21.14 R257.1
N18374804: J23.36 R545.2
N18374807: J23.37 R549.2
N18374810: J23.38 R550.2
N18374813: J23.39 R551.2
N18516151: R109.1 U25.A3(ALERT)
N18520654: R67.1 U17.A3(ALERT)
N18571509: R568.2 U123.5(2DIR)
N18571515: R565.1 U123.4(1DIR)
N18576337: R342.2 U78.39(GPIO_0)
N18576340: R341.2 U78.40(GPIO_1)
N18736007: C426.2 U88.14(MIC3R)
N18736028: R437.2 U88.13(MICBIAS)
N19082749: R42.1 R43.1 U9.3(OUTPUT)
N19361712: LD7.1(CATHODE) Q12.3(D)
N19806973: R529.2 U114.7(1A2)
N20199452: D1.3(C) R124.2 R125.1
N20506305: L8.1 U43.11(L1)
N20506307: L8.2 U43.9(L2)
N20506388: R469.1 U43.6(FB2)
N20506390: R197.1 U43.2(PG)
N20506392: R199.2 U43.1(PS/SYNC)
N20506511: C136.1 U43.3(VAUX)
N20878915: R16.2 U5.1(A0)
N20878927: R15.1 U5.2(A1)
N20878931: R32.2 U5.11(I\N\T\)
N20900570: R35.1 U7.3(Y0)
N20900572: R26.1 U7.8(Y1)
N20900574: R37.1 U7.5(Y2)
N20900809: R34.1 U7.7(Y3)
N20933818: R283.2 U54.4(1DIR)
N20933822: R285.1 U54.5(2DIR)
N20936712: J12.2 R159.2
N21016640: TP24.1(TP) U78.48(VDDA1P8#48)
N21068099: R130.2 U30.1(EN)
N21079949: TP27.1(TP) U78.14(XO)
N21197992: TP7.1(TP) U2.16(P17)
N21197993: TP4.1(TP) U2.15(P16)
N21197994: TP3.1(TP) U2.13(P14)
N21197995: TP6.1(TP) U2.14(P15)
N21197996: TP5.1(TP) U2.12(P13)
N21198784: TP2.1(TP) U2.11(P12)
N22124383: R50.2 U12.A5(NC3)
N22156088: R478.2 U99.7(SCLB)
N22156090: R476.2 U99.6(SDAB)
N22373538: R139.1 U31.2(A0) U31.7(B1)
N22424368: C432.1 R441.2
N22424482: Q2.4(G) R417.2 R418.2
N22441821: R329.2 U63.3(EN)
N22441998: R361.2 U81.1(EN)
N22442187: R325.2 U65.3(EN)
N22498870: R178.2 R182.1 U42.6(C)
N22682365: LD4.2(ANODE) R160.2
N22685157: LD2.1(CATHODE) Q8.3(COLLECTOR)
N22685161: LD2.2(ANODE) R143.1
N22685196: Q8.1(BASE) R384.2
N22685214: LD3.2(ANODE) R150.1
N22685527: LD5.1(CATHODE) Q1.1(D1) Q1.2(D2) Q1.5(D3) Q1.6(D4) Q1.8(D5)
N22685551: LD1.1(CATHODE) Q4.1(D1) Q4.2(D2) Q4.5(D3) Q4.6(D4) Q4.8(D5)
N22685595: Q4.3(G) R323.2
N22685622: LD1.2(ANODE) R62.1
N22685670: Q1.3(G) R163.2
N22685686: LD5.2(ANODE) R162.1
N22734804: J2.32(UART_TXD) R254.1
N22816067: J2.62(ALERT#) R8.1
N22885689: R374.2 U27.53(GPIO11)
N23161423: R493.1 U47.75(PM3)
N23178593: TP104.1(TP) U102.6(B2)
N23178631: TP105.1(TP) U102.3(A2)
N23178675: TP96.1(TP) U55.14(4B1)
N23178691: TP94.1(TP) U55.13(4B2)
N23178707: TP93.1(TP) U55.12(4A)
N23233575: C507.1 R95.1 U21.B1(VOUT)
N23413104: R44.1 U9.1(INH)
N23415089: R399.2 U86.1(INH)
N23696264: R410.2 R576.2 U87.5(EN)
N23989710: R582.2 U125.32(RX_CLK)
N23995034: R586.2 U125.39(GPIO_0)
N23995036: R584.2 U125.40(GPIO_1)
N23995142: FL16.2 J24.2(VCC)
N23995224: J24.11 R585.2
N23996283: R588.2 U127.3(G)
N23996295: R587.2 U126.3(G)
N23996384: R591.2 U128.3(G)
N23997204: TP123.1(TP) U125.48(VDDA1P8#48)
N23997231: TP124.1(TP) U125.13(VDDA1P8#13)
N24012713: TP125.1(TP) U125.14(XO)
N193617400: Q12.1(G) R500.2
N193617480: LD7.2(ANODE) R222.1

Pads without a net: D1 2; D2 2; J1 1 3 25 26 27 28 29 31 33 35 37 39; J2 35 37 38 40 41 42 43 44 46 47 48 49 52 53 55 58 59 60 61 64 65 66 67 68 70 71 73 SH3; J5 14; J11 4 6; J13 A2 A3 A6 A7 A8 A10 A11 B2 B3 B6 B7 B8 B10 B11; J15 A2 A3 A8 A10 A11 B2 B3 B8 B10 B11; J17 4; J19 17 18 19; J23 4 5 6 8 9 10 11 12 13 14 15 17 18 19 20 21 22 23 24 29 35; U1 6 9; U2 1 2 3 4 5 6 7 8 22; U4 8 9 12 13; U8 3 4 9 30 39 40 41 42; U12 A2 A3 B1 B5 C5; U17 B2 C2; U18 C6 D6 E7 E13 F6 G7 H2 H3 H5 H7 K2 K3 K6 L2 L5 L6 M2 M3 N2 N3 N5 N6 P4 R7 U11 V11; U20 4; U22 4 9; U25 B2 C2; U26 A1 A2 A11 A12 AA1 AA12 AB1 AB2 AB11 AB12 B1 B12 G11 K5 K8 N5 N8; U28 A1 A2 A7 A8 A9 A10 A11 A12 A13 A14 B1 B7 B8 B9 B10 B11 B12 B13 B14 C1 C3 C5 C7 C8 C9 C10 C11 C12 C13 C14 D1 D2 D3 D4 D12 D13 D14 E1 E2 E3 E5 E8 E9 E10 E12 E13 E14 F1 F2 F3 F10 F12 F13 F14 G1 G2 G3 G10 G12 G13 G14 H1 H2 H3 H12 H13 H14 J1 J2 J3 J12 J13 J14 K1 K2 K3 K6 K7 K10 K12 K13 K14 L1 L2 L3 L12 L13 L14 M1 M2 M3 M7 M8 M9 M10 M11 M12 M13 M14 N1 N3 N6 N7 N8 N9 N10 N11 N12 N13 N14 P1 P2 P7 P8 P9 P10 P11 P12 P13 P14; U29 5; U35 2 3 5 6; U37 6; U40 1; U46 2; U47 2 5 6 11 12 13 14 15 18 19 20 21 22 23 24 25 27 29 30 31 32 33 34 41 44 45 46 53 54 56 57 65 67 83 84 85 86 91 92 102 103 104 105 106 107 108 109 110 111 112 116 117 118 119 120 121 123 124 125 126 127 128; U48 18 19 21 22 23 24 30 32 33 34 36 43 44 45 46 55 57 58 59; U49 2 4 5; U52 14; U78 20 21 22 23; U79 2 3; U82 B2 C2; U83 B2 C2; U84 B2 C2; U85 B2 C2; U88 9 10 11 27 28 29 30 31 32; U90 30 31 40 41 42 43 48 50 53 54 55; U92 1; U100 17 18 19 20 21 22 23 24; U103 1; U105 7; U113 6 7; U115 1; U120 4; U121 5; U125 20 21 22 23

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 3829 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
DGND: length 1012.7
  TOP w0.102: 54.37,76.51 54.59,76.74 55.19,76.74 U28.N2 55.17,76.26 54.6,76.26 v1(54.37,76.49) 54.37,76.51
  TOP w0.178: v1(56.91,81.03) 56.43,81.51 U28.C4
  TOP w0.203: U47.10 v1(59.57,9.51) ; U47.58 68.89,19.83 v1(68.59,20.13) ; 27.32,102.84 26.92,102.44 23.46,102.44 23.24,102.22 23.24,101.49 22.98,101.22 22.98,99.94 23.23,99.69 23.23,98.33 23.43,98.13 ; v1(29.6,104.18) 27.63,104.18 27.25,104.56 25.09,104.56 C33.1 ; U54.10 23.22,39.67 v1(23.02,39.87) 22.82,39.66 U54.11 ; U41.2 v1(62.82,42.75) ; v1(55.77,14.94) 55.77,15.17 55.51,15.43 U47.114 ; C36.1 24.09,103.39 22.68,103.39 22.58,103.29 v1(21.87,103.29) 21.25,103.92 v1(21.25,104.19) 21.25,106.02 21.55,106.33 22,106.33 22.65,106.98 C31.2 ; U47.66 67.97,24.71 v1(68.17,24.91) ; U28.N5 U28.P6 57.42,75.94 v1(57.9,75.46) ; U47.48 71.19,15.83 v1(71.25,15.89) ; U24.2 v1(5.67,91.16) ; U17.B3 6.29,105.81 5.89,106.21 v1(5.82,106.21) ; Y1.4 22.98,105.36 22.32,104.7 22.32,104.53 Y1.2 ; U10.4 31.04,125.37 v1(31.41,125.73) ; U44.7 v1(66.6,26.25) ; D4.2 v1(9.45,47.28) ; 63.24,39.27 U42.2 ; v1(62.21,22.51) 62.37,22.68 U47.80 ; U28.A6 57.64,82.72 v1(57.64,83) ; U47.17 v1(62.37,7.15) ; v1(43.71,80.24) 43.71,80.25 U26.V1 ; D6.1 v1(10.66,29.95) ; U47.55 v1(71.09,18.63) ; D5.2 v1(10.42,31.48)
  TOP w0.254: U26.C1 v1(34.28,81.27) ; U12.C1 v1(51.35,122.4) 51.37,122.38 C26.1 ; C106.1 46.8,57.31 v1(46.68,57.43) ; 23.67,32.75 23.96,32.45 23.96,32.43 ; 23.67,32.75 v1(23.44,32.75) ; 23.67,32.75 24.28,32.75 ; C157.1 15.5,11.89 v1(15.69,12.08) 15.82,12.21 U48.13 ; v1(22.88,47.64) 22.53,47.99 C116.2 ; v1(35.13,85.84) 35.13,86.34 U26.E8 ; C541.1 63.3,117.45 63.18,117.45 ; SW4.4 v1(35.32,23.33) ; v1(56.42,79.26) 56.67,79.51 U28.G5 ; U48.11 15.77,13.21 v1(15.69,13.29) 15.69,13.46 15.94,13.71 U48.10 ; C75.2 62.79,87.16 v1(62.36,86.73) ; U26.A3 v1(32.33,82.07) ; U26.V5 v1(43.71,84.69) ; v1(29.96,16.89) 30.1,16.75 C152.1 ; SW4.1 v1(34.25,16.77) ; v1(70.7,22.87) 70.7,22.48 70.45,22.23 U47.64 ; U43.4 23.21,33.69 v1(22.82,34.08) 22.49,34.42 C136.2 22.57,34.9 C178.1 ; J1.SH4 v1(81.26,146.14) ; v1(45.81,57.43) 46,57.25 C109.1 ; U26.T5 v1(42.08,83.67) ; v1(47,88.25) 46.82,88.07 U26.AB10 ; C159.1 v1(73.61,10.76) ; R77.1 26.46,103.48 26.38,103.56 25.39,103.56 25.14,103.31 v1(25.14,103.06) C36.1 ; C25.1 28.77,123.17 v1(28.43,122.82) ; 23.79,105.75 23.74,105.7 v1(23.74,105.69) ; C70.2 25.71,91.14 v1(25.71,91.97) ; v1(27.21,121.1) 27.05,121.26 R48.1 ; J1.SH3 v1(77.56,146.14) ; U34.4 v1(62.38,63.76) ; U26.Y12 45.01,89.93 v1(45.51,90.43) ; v1(50.9,133.86) 51.47,134.43 U7.4 ; U26.N2 v1(40.13,81.27) ; C16.1 60.11,133.75 59.9,133.55 v1(59.56,133.55) 59.34,133.76 C14.1 ; v1(25.59,18.98) 25.32,19.25 U48.51 ; U48.25 v1(22.82,10.15) ; C148.2 v1(14.24,18.98) ; R93.1 58.36,97.78 58.61,97.52 v1(58.61,97.18) ; U28.E7 57.92,80.26 v1(58.17,80.01) ; C84.2 v1(25.17,79.58) C82.2 ; C84.2 v1(25.17,77.93) C86.2 v1(26.07,77.09) ; C84.2 v1(26.07,78.74) ; U22.5 v1(6.61,96.81) ; U3.2 55.87,147.27 55.63,147.03 C10.1 54.95,146.52 v1(54.88,146.58) R14.1 ; J15.B12 6.29,32.95 v1(7.18,32.95) J15.A1 v1(8.7,32.95) ; U26.W9 v1(44.68,86.87) U26.Y8 ; v1(45.05,135.32) 44.89,135.48 C13.1 ; R177.1 56.17,42.11 v1(55.9,42.38) ; v1(50.95,52.56) 50.72,52.34 C112.1 ; U26.N11 U26.P12 41.11,90.25 v1(40.46,90.9) ; U26.N11 U26.P10 U26.N9 ; U26.N11 v1(40.13,89.26) ; v1(3.79,153.04) J2.75 v1(1.51,153.04) ; v1(80.75,151.02) 80.62,151.14 C8.2 ; v1(1.51,151.54) J2.69 v1(3.79,151.54) ; v1(8.7,47.95) J13.A1 v1(7.18,47.95) 7.13,48 J13.B12 ; U5.7 40.82,145.43 v1(40.48,145.76) ; J2.63 v1(1.51,150.04) ; C178.1 C180.1 23.34,35.9 R283.1 ; C178.1 22.11,35.85 v1(21.95,35.69) ; U30.2 v1(66.01,71.83) ; C17.1 11.23,134.11 v1(11.14,134.02) ; U26.D9 v1(34.28,86.87) U26.C8 ; v1(66.38,39) 66.11,39.27 C133.2 ; U26.E1 35.26,80.23 v1(35.12,80.1) ; v1(67.38,68.17) C102.2 v1(66.5,69) ; U25.C1 2.96,90.82 v1(3.16,91.02) 3.54,91.4 C71.2 ; J17.5 v1(6.68,15.45) ; v1(52.4,19.52) 52.4,19.52 C147.1 ; v1(42.57,15.95) C151.2 ; R54.2 14.84,113.71 14.9,113.77 U13.70 16.26,113.77 v1(16.44,113.95) ; J2.45 v1(1.51,145.54) ; v1(5.88,95.61) 5.88,96.07 5.66,96.29 C53.1 C52.1 3.97,96.36 v1(3.3,96.36) ; U26.T10 v1(42.08,88.47) ; v1(30.68,102.07) 30.36,101.74 v1(28.5,101.74) 28.24,102 28.24,102.47 27.87,102.84 27.32,102.84 ; U26.A10 v1(32.33,88.47) ; U1.7 v1(45.05,150.03) ; v1(59.92,79.23) 59.69,79.01 U28.H10 ; C66.1 9.95,93.77 v1(9.67,94.05) ; v1(26.12,33.23) 25.95,33.06 U43.15 ; 24.28,32.75 23.96,32.43 ; 24.28,32.75 v1(24.52,32.75) ; U26.K11 v1(38.83,89.26) ; U26.K11 U26.J10 v1(38.18,87.67) U26.K9 ; U26.K11 U26.J12 37.99,89.8 37.99,90.27 v1(37.98,90.29) ; R314.2 60.58,123.8 v1(60.44,123.66) 60.24,123.46 C542.2 ; R12.1 45.86,147.43 v1(45.94,147.5) ; C111.2 v1(23.35,55.03) ; v1(58.61,117.45) 58.25,117.81 C547.2 ; v1(2.57,83.21) 2.49,83.21 2.24,83.47 C80.1 ; C57.1 v1(9.65,94.91) ; U37.5 47.54,54.07 46.63,54.07 v1(46.5,54.2) ; v1(52.83,49.54) 52.58,49.29 U40.3 ; R15.2 43.73,146.64 v1(43.75,146.67) ; R186.2 v1(46.23,37.4) R185.2 ; v1(19.98,42.67) 19.98,42.3 C130.2 ; LD3.1 49.38,53.96 v1(49.27,53.85) ; v1(20.95,47.64) 21.03,47.73 C117.2 ; C166.2 64.92,6.81 v1(64.73,7) ; J2.51 v1(1.51,147.04) ; v1(76.44,45.42) 76.11,45.09 C125.2 ; v1(68.17,24.91) 68.52,25.26 C144.1 ; C146.1 v1(60.03,24.98) ; v1(5.45,27.1) 5.65,26.9 J15.B1 ; C85.1 v1(9.53,77.82) ; v1(7.18,41.95) J13.A12 v1(8.7,41.95) ; D2.1 v1(57.01,68.79) ; v1(65.2,146.14) J1.SH2 v1(71.07,146.14) ; U12.E5 v1(46.35,124.4) ; R180.2 61.91,40.65 v1(61.91,41.31) ; U13.55 15.49,122.01 v1(15.27,122.23) R47.2 ; v1(56.26,49.32) 56.46,49.12 R164.1 ; v1(32.27,10.32) J19.20 v1(32.27,6.36) ; v1(4.36,70.51) 4.16,70.31 U31.5 ; C60.2 66.83,95.14 v1(66.83,95.14) ; v1(25.97,101.27) 25.97,100.97 26.15,100.79 C42.2 ; U26.G8 36.56,85.87 v1(36.58,85.84) ; U26.T8 42.41,85.87 v1(42.38,85.84) ; v1(55.36,26.48) C143.1 ; J5.2 7.31,111.74 v1(7.09,111.52) ; 60.9,119.74 61.33,120.17 C544.2 C536.2 C531.2 59.81,119.79 59.75,119.74 ; v1(48.8,37.48) 48.72,37.4 R187.2 ; v1(30.68,98.87) 29.3,98.87 28.5,98.06 v1(26.94,98.06) 26.87,98.13 23.43,98.13 ; U20.2 10.11,101.89 10.21,101.8 C39.2 10.87,101.8 11.13,102.05 v1(11.13,102.16) 11.26,102.03 C38.2 12.3,102.03 v1(12.42,101.91) ; C33.1 23.99,105.11 23.74,105.37 v1(23.74,105.69) ; C56.2 26.21,96.15 v1(26.72,96.15) ; v1(66.05,42.48) 65.78,42.75 C127.2 ; v1(2.56,72.54) 2.66,72.65 U31.9 ; C110.1 v1(9.98,55.3) ; C113.2 22.86,51.26 v1(22.86,51.84) 22.86,52.35 R155.2 ; v1(56.59,144.21) 56.84,144.46 C11.1 ; v1(56.34,75.43) 56.42,75.5 U28.P4 ; J2.33 v1(1.51,142.54) ; v1(58.48,37.41) 58.48,37.74 58.18,38.04 R184.2 ; R152.2 76.19,54.48 76.44,54.73 v1(76.62,54.73) 76.89,54.73 77.1,54.52 R153.2 ; C21.2 v1(45.14,124.3) ; R21.1 50.04,141.16 v1(50.31,140.89) 50.33,140.87 U4.11 ; C31.2 v1(23.36,107.03) ; U26.C12 33.57,90.14 v1(33.58,90.19) ; v1(19.3,52.73) 19.06,52.49 U38.4 ; v1(53.12,100.59) 53.12,100.06 C44.2 ; C124.2 75.07,45.24 v1(74.91,45.4) ; U48.5 v1(15.72,16.21) 15.46,15.95 C149.2 v1(14.24,15.95) ; v1(21.73,78.92) 21.92,78.92 22.08,78.75 v1(22.13,78.75) 21.92,78.54 U27.5 ; R18.1 47.83,144.63 v1(47.97,144.49) ; v1(8.7,26.95) J15.A12 v1(7.18,26.95) ; U26.D11 v1(34.28,88.47) ; C63.2 63.3,94.89 v1(63.18,94.89) ; v1(21.39,121.07) 21.69,121.38 U13.43 ; LD10.1 v1(52.82,6.33) ; R64.2 16.37,106.73 v1(16.5,106.86) 16.42,106.94 R63.2 ; C137.1 63.37,34.23 v1(62.63,33.48) ; v1(48.63,102.07) 48.23,101.67 U18.AB9 ; v1(26.02,81.79) 25.77,82.04 C81.2 v1(25.17,81.23) C82.2 ; v1(22.88,45.16) 22.98,45.16 C122.2 ; LD9.1 48.22,9.92 v1(47.92,10.22) ; U26.D4 v1(34.93,83.67) U26.E5 ; v1(5.88,94.88) 5.67,94.67 C65.2 ; C68.2 25.45,93.03 v1(25.71,92.77) ; v1(60.44,101.11) 60.24,100.9 C43.2 ; R174.2 61.44,44.29 61.81,44.66 v1(61.81,44.69) ; v1(66.83,93.64) 66.83,93.64 C67.2 ; v1(67.58,150.61) J1.12 ; C115.2 v1(77.05,49.29) ; C105.2 v1(56.01,60.51) ; C88.1 1.58,75.92 v1(1.4,76.1) ; v1(24.62,95.73) C526.2 22.92,95.73 v1(22.9,95.75) ; U26.T12 v1(42.41,90.29) ; J2.39 v1(1.51,144.04) ; v1(18.47,56.05) 18.67,56.25 U36.2 ; U33.8 v1(55.15,61.98) ; v1(26.07,75.44) C382.2 v1(25.17,76.28) ; v1(46.31,84.69) U26.AB5 ; U26.T1 v1(42.41,80.24) ; U26.P1 v1(40.85,80.24) ; U9.2 v1(24.84,124.28) ; Q1.7 Q1.4 56.93,49.74 v1(57.15,49.52) ; v1(53.12,98.75) 53.12,99.22 C46.2 ; v1(23.74,105.69) 23.67,105.75 23.19,105.75 Y1.4 ; U29.2 40.14,74.82 v1(40.31,74.99) 40.53,75.21 R129.2 ; C12.1 50.42,139.41 50.68,139.16 v1(50.68,139.03) 50.68,138.9 50.42,138.65 C15.1 ; J19.12 v1(37.35,6.28) ; v1(72.91,24.23) 73.22,23.92 R225.1 R229.1 R230.1 R231.1 ; SW5.4 v1(42.18,23.33) ; U25.B3 1.44,90.42 v1(1.23,90.63) 1.42,90.82 U25.C3 ; U45.3 69.68,25.91 v1(69.45,25.68) ; U26.W4 v1(44.68,83.67) U26.Y5 ; C107.1 20.68,57.11 v1(20.68,57.49) ; C51.2 21.82,98.28 v1(21.99,98.45) 22.21,98.22 C47.2 ; 23.96,32.43 U43.10 ; J5.17 v1(7.04,119.24) ; U27.42 12.74,76.54 v1(12.17,75.97) ; v1(20.31,126.21) 20.58,125.94 C20.1 ; U2.25 52.01,152.59 v1(52.44,153.03) ; C82.2 v1(26.07,80.39) ; U26.G3 v1(36.88,82.07) ; J2.SH2 v1(1.56,154.14) ; U26.E12 35.26,90.86 v1(35.28,90.88) ; U18.R6 v1(42.68,98.87) ; U46.4 v1(9.65,17.26) ; C160.1 v1(14.95,9.66) ; C3.1 11.33,153.48 v1(11.08,153.73) ; D7.1 7.97,20.25 v1(7.94,20.28) ; U6.2 v1(46.9,136.5) ; v1(1.3,135.78) 1.57,136.04 J2.7 ; v1(39.01,83.22) 38.97,83.27 U26.K4 ; R188.2 49.39,37.95 v1(49.2,38.14) 48.61,38.73 C134.1 ; v1(46.31,85.84) U26.AB8 ; C9.1 v1(38.99,150.37) ; J5.11 v1(7.09,116.24) ; C64.1 19.33,94.63 v1(19.22,94.74) ; J2.57 v1(1.51,148.54) ; C540.2 66.83,116.2 v1(66.83,116.19) ; U18.Y12 U18.W11 ; D8.1 v1(77.05,13.16) ; v1(12.4,40.04) 12.63,40.27 C132.2 ; C533.2 54.92,117.37 v1(54.92,117.31) 55.02,117.31 C549.2 ; v1(48.9,43.24) 47.79,43.24 Q3.3 ; C142.2 v1(73.87,28.84) ; v1(53.24,110.61) C515.2 v1(53.24,108.88) 53.55,108.88 53.73,108.7 C30.2 ; v1(66.83,96.64) 66.83,96.64 C300.2 ; C507.2 22.1,96.73 v1(21.99,96.61) 21.58,96.61 U21.A1 ; C87.1 v1(34.8,76.33) ; U11.3 v1(39.61,123.38) ; 63.24,39.27 62.27,39.27 v1(61.44,38.44) ; R104.2 4.04,93.82 v1(3.57,94.29) ; U26.C5 v1(33.63,83.67) ; C54.2 63.72,96.64 v1(63.18,97.18) ; R599.1 58.4,119.06 58.61,118.85 v1(58.61,118.59) ; v1(20.36,35.31) 20.36,35.67 20.61,35.92 R195.2 ; C5.1 v1(54.71,153.12) ; R5.1 v1(57.52,153.4) ; v1(43.87,85.84) 43.71,86.01 U26.V8 ; D1.1 v1(65.79,79.57) ; C58.2 54.92,94.81 v1(54.92,94.76) 55.02,94.76 C61.2 ; 72.16,7.37 v1(71.57,7.37) 71.39,7.55 U49.1 ; R232.2 v1(76.05,19.58) ; v1(58.61,94.89) 58.25,95.25 C59.2 ; C545.2 62.24,109.77 v1(61.61,109.15) ; J7.4 v1(73.31,75.8) ; U26.G1 v1(36.23,80.47) ; v1(57.28,6.25) 57.41,6.12 C167.2 C164.2 ; v1(59.94,26.12) 59.94,26.45 Y4.2 ; v1(22.88,42.67) 22.88,41.86 C131.2 ; v1(32.67,123.56) 32.45,123.78 C22.2 ; v1(52.24,16.72) 52.42,16.54 C150.2 ; J19.10 v1(38.62,6.28) ; Y4.4 v1(57.35,27.8) ; C101.2 v1(58.83,68.14) ; C165.1 v1(60.99,6.88) ; v1(30.82,11.73) C158.1 29.42,11.73 29.4,11.71 U48.35 ; U26.Y1 v1(44.68,81.27) U26.W2 ; U26.AB3 v1(45.98,82.07) ; C534.2 66.83,119.2 v1(66.83,119.19) ; v1(36.69,84.69) 36.56,84.55 U26.G5 ; U13.63 v1(16.49,117.27) ; R190.2 v1(52.57,37.4) R191.2 ; J2.1 v1(1.51,134.54) ; R595.1 58.36,120.33 58.61,120.08 v1(58.61,119.74) ; R36.1 48.06,134.06 v1(48.53,134.06) 48.81,134.06 C19.2 ; C156.2 52.85,13.07 v1(53.13,13.35) ; C40.2 v1(4.45,101.92) ; v1(41.82,16.68) 41.11,17.39 SW5.1 ; U27.52 18.24,77.08 v1(18.51,77.35) ; v1(58.61,93.75) 57.93,94.43 C62.2 ; U28.J5 v1(57.67,78.51) 58.14,78.51 58.42,78.23 U28.K8 ; J5.8 v1(7.09,114.74) ; v1(58.61,96.04) 58.61,96.3 58.4,96.51 R96.1 ; C37.2 v1(3.84,103.44) ; C96.2 v1(66.89,70.09) ; C162.1 v1(22.01,7.03) ; v1(25.95,99.69) 26.12,99.85 C45.2 ; U48.15 18.01,11.21 v1(18.06,11.26) ; U35.4 v1(10.85,58.12) ; C2.2 v1(13.49,153.7) ; U26.J1 v1(37.86,80.24) ; U26.P3 v1(40.78,82.87) ; v1(14.68,120.27) U13.57 ; R154.2 16.37,53.49 v1(16.05,53.17) 16.5,52.73 R156.2 ; R141.2 v1(49.55,65.86) ; v1(58.61,116.31) 57.93,116.98 C537.2 ; C6.1 v1(38.99,151.19) ; J18.5 v1(77.67,18.05) ; J1.SH1 v1(61.53,146.14) ; J13.B1 v1(5.48,41.9) ; R144.1 v1(49.56,60.96) ; J1.16 v1(69.08,150.61) ; U26.D2 v1(34.28,82.07) ; v1(6.96,104.2) 6.69,104.47 U17.C1 ; J2.18 v1(11.41,138.79) ; J5.5 v1(7.12,113.24) ; C153.2 52.85,14.18 52.59,13.93 v1(52.41,13.93) 52.3,14.05 C154.2 ; Y1.2 v1(21.25,104.19) ; U12.B3 v1(49.35,120.4) ; LD6.1 v1(12.52,26.54) ; U26.K2 v1(38.83,81.27) ; U26.N4 39.99,83.27 v1(39.95,83.22) ; C548.2 63.72,119.2 63.18,119.74 ; FL2.1 v1(2.8,104.95) ; C1.1 v1(48.03,153.79) ; C155.2 v1(75.62,12.71) ; R7.1 v1(46.15,152.77) ; C89.1 v1(9.53,74.77) ; C104.2 v1(8.29,61.45) ; v1(44.03,88.46) U26.W11 44.03,89.26 U26.V12 ; R221.1 v1(71.91,24.45) ; v1(17.26,103.72) 17.26,104.03 C35.1 ; U18.T5 v1(43.48,98.07) ; C95.2 v1(66.05,70.07) ; U48.1 v1(18,18.21) ; v1(59.75,97.18) 59.81,97.23 C48.2 C49.2 C50.2 61.33,97.61 v1(60.9,97.18) ; C145.1 v1(57.82,24.98) ; U32.3 v1(61.08,71.02) ; R192.2 v1(53.87,37.4) ; R189.2 v1(50.66,37.96) ; C119.2 v1(77.05,48.29) ; U26.T3 v1(42.08,82.07) ; v1(66.83,117.69) 66.83,117.7 C543.2 ; U48.47 v1(29.48,17.71) ; U16.2 v1(19.15,106.52) ; R159.1 61.27,49.72 v1(60.94,49.72) ; U26.J3 v1(38.18,82.86) ; J1.24 v1(72.08,150.61) ; U26.G10 v1(36.88,88.47) ; U26.G12 v1(36.88,89.26) ; D3.1 v1(10.11,54.16)
  TOP w0.279: U27.6 21.61,79.04 v1(21.73,78.92)
  TOP w0.305: U18.AB18 v1(48.28,109.26) ; U18.W11 v1(45.88,102.87) ; U18.Y12 v1(46.68,104.46) ; R238.2 51.98,6.35 v1(52.26,6.07) ; C163.1 26.8,6.13 v1(26.86,6.07) ; v1(19.31,102.07) C522.2 v1(19.31,103.75) ; J19.16 34.81,6.4 v1(34.48,6.07) ; v1(25.33,85.2) 25.33,85.21 C79.1 ; U18.U2 v1(44.28,95.67) ; v1(25.78,109.21) C528.2 v1(25.78,107.63) 25.6,107.45 C32.2 ; C103.1 v1(49.62,67.27) ; U18.AB5 v1(48.28,98.07) ; U27.51 v1(17.74,76.45) ; v1(17.37,84.58) 17.24,84.45 U27.21 ; U18.AB22 v1(48.28,112.47) ; v1(37.88,99.67) U18.K7 v1(38.68,100.47) ; C41.2 v1(17.96,101.33) ; U18.E5 v1(33.88,98.07) ; U18.D4 v1(33.08,97.26) ; U18.R6 v1(41.88,98.87) ; U27.36 v1(13.65,79.54) ; U18.T1 v1(43.08,94.6) ; U18.AB3 v1(48.28,96.47) ; 44.68,95.27 U18.V1
  TOP w0.356: U18.U14 v1(44.28,106.06) ; U18.A10 v1(30.68,102.07) ; U18.AB1 v1(48.28,94.86) ; U18.B5 v1(31.48,98.07) ; U18.AA14 U18.AB15 v1(48.61,106.47) ; U18.P11 v1(41.88,102.87) ; U18.M7 v1(40.28,99.67) ; U18.T7 v1(43.48,99.67) ; 44.68,95.27 v1(45.08,95.67) U18.W2 ; U18.P15 v1(41.88,106.86) ; U18.AA11 v1(47.48,102.87) ; U18.R4 v1(42.68,97.27) ; U18.R14 v1(42.68,106.06) ; U18.W4 v1(45.88,97.26) ; U18.M4 v1(40.28,97.27) ; U18.A6 v1(30.68,98.87) ; U18.G12 v1(35.48,104.46) ; U18.P20 v1(41.88,110.86) ; U18.Y3 v1(46.68,96.47) ; U18.AA8 v1(47.48,100.47) ; U18.U9 v1(44.28,101.27) ; U18.L20 v1(38.68,110.86) ; U18.F13 v1(34.68,105.26) ; U18.U4 v1(44.28,97.27) ; U18.D2 v1(33.08,95.67) ; U18.AA4 v1(47.48,97.27) ; U18.J17 v1(37.08,108.46) ; U18.P13 v1(41.88,105.26) ; U18.L12 v1(38.68,104.46) ; U18.A4 v1(30.68,97.26) ; U18.P7 v1(41.88,99.67) ; U18.H14 v1(36.28,106.06) ; U18.P17 v1(41.88,108.46) ; U18.K4 v1(37.88,97.27) ; U18.E1 v1(33.88,94.87) ; U18.Y5 v1(46.68,98.07) ; U18.M11 v1(40.28,102.87) ; U18.R16 v1(42.68,107.66) ; U18.U6 v1(44.28,98.87) ; U18.Y9 v1(46.68,101.27) ; U18.A13 v1(30.68,105.26) ; U18.G5 v1(35.48,98.07) ; U18.G9 v1(35.48,101.27) ; U18.T17 v1(43.48,108.46) ; U18.N14 v1(41.08,106.06) ; U18.F2 v1(34.68,95.67) ; U18.J3 v1(37.08,96.47) ; v1(38.68,95.67) U18.K1 v1(37.88,95.67) ; U18.L14 v1(38.68,106.06) ; v1(48.54,104.46) 48.14,104.07 U18.AB12 ; U18.K11 v1(37.88,102.87) ; U18.W6 v1(45.88,98.87) ; U18.V9 v1(45.08,101.27) ; U18.N1 v1(41.08,94.87) ; U18.V3 v1(45.08,96.47) ; U18.D11 v1(33.08,102.87) ; U18.V20 v1(45.08,110.86) ; U18.L3 v1(38.68,96.47) ; U18.A1 v1(30.68,94.86) ; U18.F4 v1(34.68,97.27) ; U18.G3 v1(35.48,96.47) ; U18.G17 v1(35.48,108.46) ; U18.V7 v1(45.08,99.67) ; U18.F16 v1(34.68,107.66) ; U18.N10 v1(41.08,102.07) ; U18.H11 v1(36.28,102.87) ; U18.A18 v1(30.68,109.26) ; U18.D20 v1(33.08,110.86) ; U18.F11 v1(34.68,102.87) ; U18.V5 v1(45.08,98.07) ; U18.E3 v1(33.88,96.47) ; U18.A22 v1(30.68,112.47) ; U18.B7 v1(31.48,99.67) ; U18.M17 v1(40.28,108.46) ; U18.R12 v1(42.68,104.46) ; U18.H4 v1(36.28,97.27) ; U18.T5 v1(42.68,98.07) ; U18.W8 v1(45.88,100.47) ; U18.C4 v1(32.28,97.27) ; U18.N12 v1(41.08,104.46) ; U18.U16 v1(44.28,107.66) ; U18.R10 v1(42.68,102.07) ; U18.B3 v1(31.48,96.47) ; U18.U12 v1(44.28,104.46) ; U18.H20 v1(36.28,110.86) ; U18.H1 v1(36.28,95.67) ; U18.T15 v1(43.48,106.86) ; U18.AA2 v1(47.48,95.67) ; U18.N16 v1(41.08,107.66) ; U18.W14 v1(45.88,106.07) ; U18.R2 v1(42.68,95.67) ; U18.K9 v1(37.88,101.27) ; U18.J12 v1(37.08,104.46) ; v1(42.68,96.47) U18.T3 ; U18.N8 v1(41.08,100.47) ; U18.Y15 v1(46.68,106.86)
  TOP w0.381: SW1.4 v1(7.37,57.76) ; v1(12.76,133.3) C18.2 v1(13.49,133.89) ; SW1.1 v1(1.87,57.76)
  L03_SIG01 w0.14: v1(17.74,76.45) 19.9,76.45 20.47,77.03 20.47,84.04 24.67,88.23 24.67,93.21 26.03,94.58 26.03,98.38 27.94,100.28 28.64,100.28 30.43,102.07 v1(30.68,102.07) ; v1(36.28,102.87) 36.55,103.14 36.55,103.44 36.3,103.7 30.23,103.7 28.7,102.17 28.32,102.17 27.78,101.63 27.54,101.63 26.07,100.16 25.73,100.16 24.73,99.17 24.73,97.31 23.81,96.38 22.81,96.38 22.46,96.03 22.46,88.19 20.2,85.93 17.71,85.93 17.44,85.66 17.44,84.65 v1(17.37,84.58)
  L03_SIG01 w0.254: v1(72.68,105.32) 77.36,105.32 77.69,105.64 77.69,106.4 v1(77.63,106.47)
  BOTTOM w0.086: U117.3 39.82,16.51 v1(39.86,16.55) ; U107.3 v1(46.02,24.83)
  BOTTOM w0.14: 69.29,38.16 69.24,38.11
  BOTTOM w0.178: U112.4 63.51,20.96 v1(63.72,21.17) ; U102.4 62.46,27.29 62.51,27.23 v1(62.6,27.23) ; U106.4 48.64,23.44 48.5,23.3 47.96,23.3 v1(47.69,23.03)
  BOTTOM w0.203: v1(19.98,42.67) 19.78,42.46 U90.51 ; v1(27.09,9.34) 27.22,9.34 27.7,8.86 U123.16 ; D11.2 5.29,27.25 v1(5.45,27.1) ; U109.3 56.93,21.07 v1(56.8,21.21) ; U51.6 47.39,140.54 v1(47.48,140.45) ; v1(22.1,11.75) 21.79,12.06 U119.12 ; v1(36.19,34.2) 36.19,34.48 C443.2 ; U109.5 59.4,21.47 v1(59.6,21.27) 59.4,21.07 U109.6 ; U118.11 26.78,14.77 v1(26.98,14.97) 26.8,15.15 26.43,15.15 26.41,15.17 U118.10 ; U122.6 40.73,10.06 v1(40.53,10.26) 40.33,10.06 U122.5 ; v1(56.34,75.43) 56.56,75.21 C384.2 ; U119.9 21.76,13.26 v1(22.07,13.57) ; D10.2 5.1,45.02 v1(5.35,45.28) ; U90.20 19.78,47.85 v1(19.98,47.64) ; U123.10 29.32,6.88 v1(29.12,6.68) 28.92,6.88 U123.11 ; v1(15.9,133.9) 16.06,134.05 U57.B1 16.37,133.68 16.26,133.57 ; v1(21.03,14.62) 20.71,14.31 U119.7 ; U114.10 49.06,17.9 v1(48.86,17.7) 48.66,17.9 U114.11 ; U119.10 21.9,12.86 v1(22.1,12.66) 21.9,12.46 U119.11 ; U122.3 v1(40.73,7.48) ; v1(27.88,9.84) 27.99,9.84 28.52,9.31 U123.1 ; U116.2 v1(32.91,15.35) ; U111.11 v1(68.59,20.13) 68.19,20.53 U111.10 ; U110.10 30.01,19.04 v1(29.81,18.84) 29.61,19.04 U110.11
  BOTTOM w0.254: J21.3 v1(15.47,152.23) ; v1(15.72,16.21) 15.72,16.2 15.98,15.94 R553.1 ; C195.2 v1(51.35,122.4) ; v1(37.89,34.23) 38.05,34.39 C442.1 ; R469.2 22.77,34.03 v1(22.82,34.08) ; C279.2 44.04,101.03 v1(44.28,101.27) ; C468.1 28.77,22.27 ; 28.77,22.27 28.77,22.08 29.21,21.64 U110.1 ; 28.77,22.27 v1(28.2,21.7) 28.2,21.29 28.46,21.03 U110.16 ; U120.1 46.78,10.06 v1(47.27,9.57) ; U55.8 51.41,139.04 51.15,139.3 51.15,139.84 v1(51.34,140.04) ; C420.2 37.43,44.94 v1(37.01,45.36) U89.16 ; v1(70.3,42.35) 70.3,42.48 C425.2 ; U120.6 44.78,11.4 v1(44.87,11.31) ; C474.2 v1(46.21,20.64) ; C252.2 51.78,104.95 51.8,104.95 v1(51.89,105.03) 51.89,105.01 52.36,104.54 C251.2 ; v1(8.68,136.68) 8.37,136.37 C179.2 7.89,135.9 v1(8.08,135.71) ; C470.2 v1(76.09,22.19) ; C470.2 v1(76.09,20.79) ; C470.2 v1(76.81,21.47) ; R489.2 47.24,27.44 47.13,27.55 U100.25 47.13,28.99 v1(46.83,29.3) ; v1(66.83,96.64) 66.79,96.64 66.78,96.64 C293.2 ; v1(77.79,28.41) R487.2 ; v1(45.85,21.93) 46.08,22.16 C466.1 ; R611.2 66.42,113.34 66.13,113.05 C556.1 66.13,112.15 v1(66.14,112.15) ; v1(38.67,20.43) 38.49,20.25 U108.4 ; v1(20.86,99.81) 20.98,99.81 21.23,100.06 C280.2 ; C177.2 v1(22.12,138.25) ; v1(55.83,36.77) 56.11,36.49 U96.2 ; v1(46.69,39.81) 46.9,40.01 U94.3 ; U113.5 v1(13.92,17.46) ; v1(21.39,121.07) 21.27,121.19 21.27,121.55 C197.2 ; v1(10.55,24.42) 10.27,24.7 U104.2 ; C183.1 59.81,133.07 59.56,133.32 v1(59.56,133.55) ; v1(7.27,126.07) 7.82,125.52 C190.2 ; U98.12 53.72,33.17 v1(53.71,33.16) ; C259.2 42.82,103.96 C253.2 ; C43.2 60.24,100.9 v1(60.44,101.11) ; v1(41.88,102.87) 41.66,102.64 C514.2 41.3,102.29 41.3,102.29 v1(41.08,102.07) ; C192.2 v1(12.14,123.92) ; v1(41.88,99.67) U18.P7 41.3,100.24 v1(41.08,100.47) 40.96,100.59 C278.2 ; v1(31.92,17.86) 32.35,17.43 C487.1 ; R567.1 v1(43.31,11.41) ; v1(73.32,150.71) 73.58,150.46 J20.16 ; C540.2 66.78,116.2 66.79,116.19 v1(66.83,116.19) ; C410.2 v1(10.8,51.45) ; U63.5 70.25,105.79 U63.2 ; v1(71.66,15.13) 71.66,15.12 C492.2 ; Q6.4 Q6.7 v1(78.27,83.8) ; v1(10.7,125.82) 10.4,125.52 C189.1 ; v1(39.01,83.22) 39.1,83.13 C351.2 39.86,83.13 v1(39.95,83.22) ; R423.2 v1(29.09,45.86) ; v1(60.28,22.55) 60.11,22.72 C464.1 ; v1(27.88,9.84) 27.88,10.18 C502.1 ; C230.2 70.52,107.47 v1(70.73,107.68) ; C230.2 70.52,106.69 70.57,106.64 U63.2 ; C230.2 v1(71.07,107.02) ; U101.12 38.61,28.98 v1(38.62,28.99) ; v1(66.83,93.64) 66.79,93.64 66.78,93.64 C67.2 ; v1(9.76,84.24) 10.17,83.83 C349.2 ; C174.1 46.58,144.42 v1(46.63,144.48) 46.5,144.61 C172.1 ; C203.2 v1(16.35,118.77) ; v1(66.83,117.69) 66.79,117.69 66.78,117.7 C543.2 ; U65.2 65.48,104.78 U65.5 ; U65.2 v1(65.15,105.65) ; U65.2 64.19,105.1 C249.2 v1(64.16,105.58) ; J22.6 5.53,95.26 ; 5.53,95.26 5.53,95.23 v1(5.88,94.88) ; 5.53,95.26 v1(5.88,95.61) ; U89.3 v1(31.72,45.36) ; C491.1 v1(10.51,14.78) ; C435.1 v1(53.2,37.96) ; R440.2 63.23,42.34 v1(62.82,42.75) ; C206.2 22.49,116.02 v1(22.48,116.01) ; U79.4 15.78,94.03 J22.SH4 15.2,94.28 v1(14.53,94.28) ; C477.1 v1(55.73,19.59) ; v1(26.3,111.71) 26.17,111.83 C211.2 ; R462.2 v1(32.75,37.4) R461.2 v1(34.02,37.4) R460.2 ; C441.1 v1(27.88,35.65) ; C546.2 66.78,119.2 66.79,119.19 v1(66.83,119.19) ; C199.2 46.37,120.42 v1(46.35,120.4) ; C417.2 13.53,48.34 v1(13.15,48.34) ; v1(65.82,132.98) 65.94,132.86 C188.1 ; v1(20.96,10.45) 20.71,10.7 U119.14 ; v1(25.59,18.98) 25.82,19.21 25.82,19.75 C480.2 ; v1(61.75,12.25) J23.25 ; v1(66.25,12.25) J23.16 ; U92.25 56.2,39.64 v1(56.43,39.42) 56.39,39.38 R452.1 ; v1(61.53,146.14) 61.23,146.44 R251.2 61.23,147.37 v1(61.11,147.49) ; R605.1 R594.1 59.53,126.1 v1(59.34,126.28) ; R463.1 47.46,37.54 v1(47.6,37.68) ; v1(43.48,106.86) 43.48,106.87 C512.2 v1(42.68,107.66) ; v1(5.67,91.16) 5.42,90.91 R619.1 ; J20.13 v1(72.08,150.61) ; U58.6 v1(4.04,113.96) ; U98.11 52.01,33.65 v1(51.92,33.57) ; C473.1 65.1,21.3 64.75,21.64 64.59,21.64 v1(64.56,21.68) ; C490.1 23.53,16.06 23.23,16.37 v1(22.99,16.37) ; v1(12.42,109.3) 12.29,109.16 C219.2 ; v1(19.15,106.52) 18.88,106.25 18.6,106.25 R324.1 ; v1(21.62,134.76) 21.42,134.96 U56.2 ; C456.2 55,26.84 v1(55.36,26.48) ; C242.2 v1(68.28,105.38) ; U53.B1 6.11,136.29 6.05,136.23 C181.2 5.55,135.73 v1(5.41,135.6) ; v1(47.48,100.47) 47.62,100.47 R344.2 ; C429.2 v1(33.6,39.44) ; D13.1 v1(37.07,16.6) 37.7,15.97 C488.1 ; R457.2 v1(39.1,37.4) R456.2 ; C90.1 v1(25.79,68.1) ; v1(30.52,10.72) 30.16,10.36 C503.1 ; C409.2 68.74,52.49 v1(69.17,52.49) ; C459.1 66.58,26.27 v1(66.6,26.25) ; C421.1 29.44,44.59 v1(29.11,44.92) ; v1(52.6,26.58) 52.6,26.76 C457.1 ; v1(76.85,24.24) 77.17,24.57 U105.6 ; C171.2 v1(60.33,145.35) ; C476.1 18.25,20.72 v1(18.13,20.84) ; v1(51.29,141.7) 51.09,141.9 R256.1 ; v1(34.25,16.77) 34.61,16.77 34.86,17.02 C485.1 ; C287.2 35.6,99.79 v1(35.48,99.67) ; v1(15.88,136.45) C182.2 v1(15.13,135.67) ; U89.9 34.03,46.88 v1(34.28,46.63) ; C454.1 63.42,28.81 63.68,29.06 v1(63.77,29.06) ; J21.7 v1(20.55,151.92) ; v1(24.02,18.32) 24.14,18.2 R540.1 ; v1(80.93,83.78) Q7.7 Q7.4 ; U89.A1 32.1,43.42 v1(31.77,43.42) ; C423.2 13.24,43.31 ; C432.2 v1(37.09,39.71) C433.2 ; v1(41.09,11.42) 41.1,11.4 C501.1 ; U101.13 37.11,28.98 v1(37.1,28.99) ; C208.2 v1(17.63,113.94) ; R445.2 22.77,39.6 23.02,39.85 v1(23.02,39.87) ; v1(9.99,113.96) U58.19 ; v1(38.68,104.46) 38.68,104.44 C509.2 39.85,103.26 ; R413.1 18.05,51.08 v1(17.93,50.97) ; J22.SH2 v1(0.97,92.27) ; C310.2 60.34,89.61 v1(59.96,89.23) 59.58,89.61 C311.2 ; C461.2 73.7,26.5 v1(73.85,26.65) ; v1(66.9,102.86) C256.2 66.44,103.57 v1(66.32,103.44) ; R271.1 v1(4.9,138.92) ; v1(66.55,150.61) 66.08,150.14 J20.1 ; v1(25.95,99.69) 25.91,99.65 C289.2 ; v1(62.56,102.58) 62.39,102.58 62.13,102.32 R337.1 ; C553.2 59.58,112.16 v1(59.96,111.78) 60.34,112.16 C552.2 ; R459.2 v1(36.56,37.4) R458.2 ; U52.8 40.49,139.38 40.24,139.64 v1(39.83,139.64) ; U121.3 v1(12.39,9.44) ; 37.88,103.62 C510.2 v1(37.88,102.87) ; C358.2 56.79,81.15 v1(56.91,81.03) ; U128.7 U128.4 v1(76.23,129.59) ; R315.2 34.44,114.48 v1(34.68,114.24) ; R455.2 v1(41.56,37.4) ; C465.1 v1(51.22,21.94) ; v1(75.62,12.71) v1(75.62,12) 75.62,10.13 J23.41 ; C413.2 v1(30.8,50.56) ; v1(18.59,121.09) 18.59,121.22 C196.2 ; v1(58.48,37.41) 58.48,37.3 58.23,37.05 C439.1 ; C498.1 C497.2 v1(11.07,13.03) 10.59,13.52 C495.1 ; v1(47.48,95.67) U18.AB1 v1(48.28,94.86) ; 4,67.86 v1(4.93,67.86) ; C185.1 v1(11.14,134.02) ; R284.1 61.02,135.46 v1(61.24,135.68) ; R604.1 62.13,124.88 62.39,125.14 v1(62.56,125.14) ; v1(71.1,12.08) 71,12.08 70.75,12.33 J23.7 ; C424.2 69.53,42.23 v1(69.35,42.05) ; v1(46.5,55.47) 46.41,55.56 R400.1 ; v1(44.28,104.46) 44.16,104.34 C254.2 ; C379.2 60.42,78.73 v1(59.92,79.23) ; v1(15.56,100.55) 15.61,100.49 J22.SH3 ; C218.2 39.8,107.81 C225.2 ; v1(28.5,103.01) C527.2 ; v1(41.88,105.26) 41.66,105.49 C508.2 v1(41.08,106.06) ; C538.2 65.27,125.07 v1(65.02,125.33) ; R351.2 66.42,90.78 66.13,90.5 C307.1 66.13,89.6 v1(66.14,89.59) ; R568.1 32.04,10.09 v1(32.27,10.32) ; C356.2 54.13,82.28 v1(54.36,82.51) 54.38,82.49 C357.2 ; C482.1 v1(62.32,17.03) ; R311.2 48.61,120.4 v1(49.35,120.4) 49.68,120.73 49.68,121.02 R305.2 ; v1(50.14,105.03) 50.28,104.9 R328.1 ; v1(55.23,33.16) 55.22,33.17 U98.13 ; C460.1 v1(43.01,26.8) ; C176.1 55.31,141.11 v1(54.98,140.78) ; v1(66.83,95.14) 66.79,95.14 66.78,95.14 C60.2 ; U86.2 v1(72.47,56) ; U63.2 71.03,106.12 v1(71.22,105.93) ; R442.1 v1(44.01,41.31) ; U119.16 19.91,11.31 19.66,11.05 v1(19.14,11.05) ; v1(71.08,150.61) 70.58,150.12 70.58,149.61 70.58,149.61 J20.10 ; 69.29,35.62 70.17,35.62 v1(70.5,35.95) ; v1(36.93,68.38) 36.93,68.18 36.68,67.93 U84.C3 ; C191.2 46.39,124.43 v1(46.35,124.4) ; v1(40.98,24.4) 40.86,24.27 C462.1 ; R495.1 80.91,25.78 v1(81.13,26) ; v1(52.14,23.52) C463.1 ; v1(61.89,41.97) 62.11,42.19 U93.3 ; C371.2 56.39,79.29 v1(56.42,79.26) ; v1(22.48,119.05) 22.2,119.33 C201.2 ; R253.1 43.9,146.52 v1(43.75,146.67) ; C326.2 62.05,87.64 v1(61.9,87.8) ; U115.3 76.17,17.1 v1(76.36,17.3) ; v1(57.67,149.17) 57.67,148.99 58.04,148.62 U50.4 ; Q13.3 v1(41.58,21.94) ; v1(57.25,12.25) J23.34 ; C363.2 43.67,80.98 43.4,81.25 C359.2 ; C549.2 55.17,116.98 54.92,117.24 v1(54.92,117.31) ; v1(81.4,106.86) 81.65,106.61 Q5.4 Q5.7 ; v1(59.34,103.73) 59.53,103.54 R333.1 R334.1 ; C173.1 v1(47.97,144.49) ; R560.1 19.47,15.73 v1(19.75,16.01) ; R371.2 57.93,78.25 v1(57.67,78.51) ; R491.1 59.69,26.37 v1(59.94,26.12) ; v1(64.91,18.72) 64.91,19.16 C481.1 ; J20.4 v1(67.58,150.61) ; C506.1 42.33,6.55 v1(42.6,6.28) ; R242.2 v1(25.32,153.64) ; R308.2 15.69,119.88 v1(16.47,119.88) C200.2 ; C452.1 61.5,29.57 v1(61.19,29.26) ; C215.2 53.06,109.06 v1(53.24,108.88) 53.27,108.85 C516.2 ; v1(47.38,21.53) 47.48,21.53 C472.1 ; 39.85,103.26 C260.2 ; 39.85,103.26 40.25,102.87 ; C479.1 60.39,19.57 v1(60.49,19.47) 60.87,19.85 C478.1 ; U88.21 73.16,45.15 v1(73.41,45.4) 73.66,45.15 U88.20 ; C312.2 v1(57.84,89.25) ; C236.2 v1(51.23,107.18) ; C489.2 v1(71.25,15.89) ; C554.2 v1(57.84,111.81) ; R497.1 71.81,24.35 v1(71.91,24.45) ; U83.C1 40.05,67.93 39.66,68.32 C395.2 v1(38.97,68.93) ; v1(36.02,92.62) 36.41,93.01 R349.2 ; U118.1 24.43,14.37 23.99,13.93 C493.1 23.53,13.88 23.23,13.57 v1(22.99,13.57) ; U103.3 69.62,25.86 v1(69.45,25.68) ; R255.2 53.94,142.68 v1(53.71,142.45) ; J21.11 v1(25.63,151.93) ; C438.2 v1(43.55,36.02) ; v1(40.28,99.67) 40.18,99.67 C521.2 39.38,100.47 v1(38.68,100.47) U18.K7 v1(37.88,99.67) 38.13,99.42 C518.2 38.13,98.67 ; C453.1 v1(59.78,29.52) ; C469.2 63.81,22.33 v1(64,22.52) 64,22.67 R511.2 ; C484.1 41.82,17.17 v1(41.82,16.68) ; v1(36.28,102.87) C523.2 ; R368.2 58.56,79.62 v1(58.17,80.01) ; U84.C1 35.29,67.93 34.9,68.32 C396.2 v1(34.22,68.93) ; v1(18.06,14.06) 18.3,14.06 18.61,13.75 C496.1 ; v1(15.69,13.29) 15.63,13.23 C494.1 ; C551.2 v1(57.08,111.8) ; v1(28.42,100.78) 28.42,100.73 C282.2 C283.2 ; v1(53.13,13.35) 53.13,13.35 J23.40 ; v1(64.98,102.76) 65.21,102.52 C267.2 ; v1(55.4,123.3) R602.1 ; U89.A3 v1(36.53,47.86) ; U91.2 v1(9.36,44.83) ; C471.1 50.34,21.64 v1(50.34,21.78) 50.63,21.5 50.81,21.5 R521.1 ; C427.2 v1(30.89,43) ; v1(77.63,106.47) U127.7 U127.4 ; R598.1 v1(64.15,124.42) ; C186.2 v1(9.87,134.01) ; C504.1 v1(13.78,9.59) ; v1(19.53,77.35) 19.53,77.25 19.78,77 C380.2 ; R432.1 v1(59.65,43.65) ; C292.2 v1(26.94,98.06) ; C207.2 v1(16.35,115.77) ; C419.2 69.01,46.37 v1(69.01,46.61) ; U101.11 39.58,27.11 v1(39.1,26.63) ; U104.1 v1(10.92,26.17) ; J21.8 v1(20.55,140.34) ; Q4.7 Q4.4 15.31,107.24 v1(15.07,107) ; J23.42 v1(52.35,11.57) ; R526.2 52.39,19.51 v1(52.4,19.52) ; C475.1 v1(22.82,21.38) ; J21.5 v1(18.01,152.23) ; J21.10 23.09,140.93 v1(23.33,140.7) ; v1(53.24,110.61) 53.06,110.43 C214.2 ; v1(69.95,46.5) 69.79,46.33 C418.2 U88.26 ; C434.2 v1(58.54,39.06) ; v1(60.44,123.66) 60.24,123.46 C542.2 ; J21.1 v1(12.93,146.4) ; J21.13 v1(28.17,151.92) ; C212.2 v1(21.69,113.65) ; U89.A4 v1(36.59,43.3) ; C436.2 20.63,37.24 v1(20.46,37.08) ; 12.95,44.53 v1(12.24,44.53) ; D12.1 v1(43.93,16.64) ; v1(15.9,133.9) 15.99,133.81 15.99,133.39 C184.2 ; C486.1 18.26,17.95 v1(18,18.21) ; R520.1 33.03,21.47 v1(33.18,21.62) ; C406.2 v1(70.42,52.92) ; C402.2 v1(74.18,54.58) ; U91.3 v1(9.36,44.18) ; J20.7 v1(69.08,150.61) ; R245.2 v1(58.37,153.51) ; C61.2 55.17,94.43 54.92,94.68 v1(54.92,94.76) ; U120.5 v1(44.78,9.48) ; C467.1 30.9,22.34 31.2,22.64 v1(31.2,22.88) ; v1(18.06,11.26) 18.3,11.26 18.61,11.57 C499.1 18.86,11.62 19.3,12.06 U119.1 ; U89.6 31.85,46.86 31.69,47.02 v1(31.69,47.26) ; v1(23.36,107.03) 23.69,107.36 C224.2 ; C511.2 v1(38.68,106.06) ; C381.2 12,76.47 12,76.14 v1(12.17,75.97) ; v1(76.44,45.42) 76.16,45.15 U88.15 ; R336.1 v1(64.15,101.87) ; 25.78,108.37 C529.2 v1(25.78,109.21) ; C301.2 19.33,94.85 v1(19.22,94.74) ; U82.C1 2.78,72.32 v1(2.56,72.54) 2.29,72.81 C388.2 ; Q14.3 v1(34.94,21.94) ; U118.16 24.84,13.62 24.59,13.36 v1(24.17,13.36) ; v1(51.88,101) 52.03,101 C272.2 C271.2 ; C411.2 v1(69.91,52.16) ; C168.2 v1(59.64,153.51) ; v1(9.91,117.21) 9.85,117.27 8.82,117.27 U58.14 ; v1(33.88,98.07) 34.08,98.27 C290.2 ; C288.2 29.97,99.84 C291.2 v1(30.68,98.87) ; C313.2 v1(57.08,89.24) ; U126.4 U126.7 v1(66.19,111.31) ; U85.C1 30.76,67.93 30.37,68.32 C397.2 v1(29.68,68.93) ; 80.74,151.02 v1(80.75,151.02) ; U91.1 v1(9.36,45.48) ; v1(71.07,17.79) C483.1 ; U104.3 v1(9.62,24.41) ; v1(55.4,100.75) R340.1 ; R524.1 v1(44.98,19.76) ; C210.2 v1(16.44,113.95) ; C422.2 v1(49.77,43.62) ; v1(50.94,102.07) 50.94,102.35 R331.2 ; U89.A2 v1(32.08,47.81) ; R430.2 v1(61.81,44.69) ; U95.8 v1(24.52,41.24) ; Q12.2 v1(25.4,25.66) ; 21.73,102.79 R332.2 21.97,103.04 21.87,103.14 v1(21.87,103.29) 21.73,103.15 21.73,102.79
  BOTTOM w0.305: v1(32.33,82.07) 32.45,82.18 C352.2 ; C266.2 42.9,102.29 v1(42.68,102.07) ; C268.2 41.08,101.94 v1(41.08,102.07) ; C265.2 v1(37.88,102.87) ; v1(44.28,101.27) 44.06,101.49 C275.2 ; R350.1 43.38,93.46 v1(43.5,93.57) ; v1(43.87,85.84) 43.86,85.84 C337.2 43.86,84.84 v1(43.71,84.69) ; C277.2 35.48,101.26 v1(35.48,101.27) C276.2 ; v1(35.13,85.84) 35.13,86.23 C331.2 ; v1(36.88,89.26) 36.65,89.26 C316.1 ; v1(44.28,106.06) 44.4,105.94 C238.2 ; C321.2 38.61,89.04 v1(38.83,89.26) ; C202.2 7.16,119.36 v1(7.04,119.24) ; C306.2 37.91,90.37 37.98,90.3 v1(37.98,90.29) ; v1(44.03,88.46) 43.78,88.21 43.61,88.21 ; C270.2 44.89,101.45 v1(45.08,101.27) ; C253.2 42.56,104.34 v1(42.68,104.46) ; C364.2 36.42,80.66 v1(36.23,80.47) ; v1(44.28,102.87) 44.16,102.99 C261.2 ; v1(34.66,79.24) 34.81,79.24 34.89,79.31 C374.2 C375.1 ; C362.2 38.77,81.21 v1(38.83,81.27) ; v1(42.68,106.06) 42.8,105.94 C239.2 ; v1(62.36,86.73) 62.7,87.07 C326.2 ; v1(48.28,94.86) 48.16,94.74 C298.2 ; v1(30.68,94.86) 30.05,94.86 C295.2 ; v1(30.68,94.86) 30.68,94.23 C299.2 ; v1(30.68,94.86) C525.2 ; C229.2 41.2,107.54 v1(41.08,107.66) ; v1(47,88.25) C325.2 ; C255.2 41.08,104.35 v1(41.08,104.46) C245.2 40.88,104.67 ; C237.2 40.96,106.18 v1(41.08,106.06) ; v1(44.68,81.27) 44.9,81.05 C367.2 ; C365.2 42.28,80.36 v1(42.41,80.24) ; v1(34.68,105.26) 34.88,105.47 C240.2 ; C377.2 v1(44.54,77.1) ; v1(64.56,21.68) 64.61,21.73 R517.1 ; C273.2 v1(42.68,102.07) ; v1(42.68,102.07) C274.2 ; C222.2 37.32,108.22 v1(37.08,108.46) ; C373.2 v1(32.48,80.1) ; C302.2 36.02,91.99 v1(36.02,92.62) ; v1(41.88,102.87) 42,102.99 C262.2 ; v1(42.41,90.29) 42.55,90.15 C314.1 ; v1(37.08,108.46) 36.86,108.69 C217.2 ; v1(37.08,108.46) 36.83,108.21 C223.2 ; C284.2 v1(45.08,99.67) ; C264.2 34.86,102.69 v1(34.68,102.87) 34.57,102.97 C258.2 ; v1(45.98,82.07) 46.07,82.16 C353.2 ; v1(36.88,82.07) 36.7,81.89 C355.2 ; C369.1 40.73,80.13 v1(40.85,80.24) ; C227.2 44.4,107.54 v1(44.28,107.66) ; v1(32.33,88.47) 32.41,88.39 C324.2 ; C335.2 42.11,85.57 v1(42.38,85.84) 42.38,86.19 C328.2 ; v1(46.31,84.69) 46.31,84.69 C336.2 46.31,85.84 v1(46.31,85.84) ; C244.2 44.08,104.67 v1(44.28,104.46) ; v1(48.28,96.47) 48.4,96.34 C294.2 ; v1(32.33,84.69) 32.11,84.47 C343.2 ; v1(45.88,98.87) 45.76,98.99 R345.2 ; C234.2 v1(36.28,106.06) ; v1(36.28,106.06) C231.2 ; v1(36.28,106.06) C241.2 ; v1(34.93,83.67) 35.07,83.81 C341.2 ; C269.2 39.63,102.54 C263.2 39.58,102.87 v1(40.28,102.87) 40.28,103.18 C260.2 ; C286.2 v1(36.28,99.67) ; C285.2 v1(43.48,99.67) ; C221.2 v1(35.48,108.46) 35.36,108.58 C216.2 ; v1(36.58,85.84) 36.69,85.95 C332.2 ; v1(35.12,80.1) 35.04,80.18 C366.2 ; v1(39.02,92.59) C517.2 39.02,91.36 ; v1(34.28,86.87) 33.87,86.45 C333.2 ; C363.2 43.67,80.29 v1(43.71,80.24) 43.67,80.2 C370.2 ; C347.2 v1(33.63,83.67) ; v1(40.13,89.26) 40.35,89.04 C320.2 ; v1(34.68,107.66) 34.8,107.54 C226.2 ; C315.2 33.88,89.84 33.58,90.14 v1(33.58,90.19) 33.47,90.3 C305.2 ; C342.2 36.79,84.59 v1(36.69,84.69) 36.59,84.79 C338.1 ; R338.2 45.76,100.59 v1(45.88,100.47) ; v1(35.28,90.88) 35.26,90.86 C309.2 ; v1(43.48,106.86) 43.65,106.69 C235.2 ; C218.2 40.13,108.32 v1(40.28,108.46) 40.4,108.34 C220.2 ; C246.2 36.95,104.46 v1(37.08,104.46) C243.2 ; C304.2 45.45,90.5 v1(45.51,90.43) ; v1(36.88,88.47) 36.76,88.35 C322.2 ; C232.2 C233.2 38.88,106.26 v1(38.68,106.06) ; 35.68,104.67 C247.2 v1(35.48,104.46) 35.26,104.24 C257.2 ; C378.2 v1(43.16,77.1) ; C248.2 39.03,104.81 v1(38.68,104.46) 38.68,104.47 C250.2 ; C308.1 40.31,90.75 v1(40.46,90.9) 40.81,91.25 C303.2 ; C228.2 42,106.99 v1(41.88,106.86) ; C345.2 42.12,83.7 v1(42.08,83.67) 42.06,83.64 C348.2
  BOTTOM w0.381: C205.2 v1(16.49,117.27) ; U87.4 46.24,47.29 v1(46.37,47.43) ; v1(60.09,34.32) 60.7,34.93 60.7,35.01 ; v1(72.18,30) 72.03,29.85 C451.1 ; v1(65.52,41.79) 65.02,41.28 R450.1 ; v1(12.17,75.97) 12.25,75.88 C383.2 ; C350.2 25.77,82.91 v1(26.02,82.65) ; C361.2 24.43,81.04 24.98,81.04 v1(25.17,81.23) ; U99.4 62.81,33.66 v1(62.63,33.48) ; R473.1 v1(74.41,32.95) ; v1(49.27,53.85) 49.42,53.7 C408.2 ; v1(61.44,38.44) 61.77,38.76 62.07,38.76 ; v1(46.5,54.2) 46.25,53.95 R576.1
  BOTTOM w0.406: v1(1.09,118.94) 1.37,118.67 C204.2
  BOTTOM w0.432: C398.2 v1(71.11,62.57)
  BOTTOM w0.508: C213.1 11.35,110.52 v1(11.79,110.96) 11.94,111.11 12.48,111.11
  vias: v1(0.99,154.19) v1(0.99,152.91) v1(0.99,151.38) v1(0.99,149.86) v1(0.99,148.34) v1(0.99,146.81) v1(0.99,145.29) v1(0.99,143.76) v1(0.99,142.24) v1(0.99,140.72) v1(0.99,135.13) v1(0.99,133.6) v1(0.99,132.08) v1(0.99,130.56) v1(0.99,129.03) v1(0.99,127.51) v1(0.99,101.65) v1(0.99,100.13) v1(0.99,98.6) v1(0.99,9.88) v1(0.99,7.34) v1(0.99,6.07) v1(1.07,104.09) v1(1.05,103.17) v1(1.67,133.85) v1(1.67,133.04) v1(1.93,104.09) v1(1.92,103.17) v1(1.86,83.21) v1(1.96,118.94) v1(2.26,6.07) v1(2.8,104.09) v1(4.64,30.99) v1(4.64,29.01) v1(5.27,6.07) v1(5.41,136.21) v1(5.44,47.83) v1(5.44,32.83) v1(6.54,6.07) v1(6.63,98.34) v1(6.55,88.39) v1(7.12,90.99) v1(7.12,90.07) v1(7.12,89.16) v1(7.07,67.13) v1(7.47,88.39) v1(7.81,6.07) v1(7.99,67.13) v1(8.07,80.1) v1(8.07,79.19) v1(8.38,88.39) v1(8.7,20.69) v1(8.7,19.82) v1(9.12,38.94) v1(9.12,38.02) v1(9.06,23.05) v1(9.06,22.18) v1(9.08,6.07) v1(9.22,52.75) v1(9.22,50.11) v1(9.29,66.55) v1(9.29,66.05) v1(9.48,43.32) v1(9.47,42.11) v1(9.62,26.17) v1(9.65,154.19) v1(9.69,23.05) v1(9.69,22.18) v1(9.98,38.94) v1(9.98,38.02) v1(10.14,115.3) v1(10.14,52.75) v1(10.14,50.11) v1(10.17,112.35) v1(10.21,66.55) v1(10.21,66.05) v1(10.27,26.17) v1(10.35,6.07) v1(10.41,48.34) v1(10.41,47.07) v1(10.4,43.32) v1(10.38,42.11) v1(10.37,40.9) v1(10.51,10.6) v1(10.51,9.58) v1(10.69,117.96) v1(10.9,38.94) v1(10.9,38.02) v1(10.9,37.03) v1(10.9,36.19) v1(11.18,154.19) v1(11.32,54.69) v1(11.32,53.42) v1(11.32,52.15) v1(11.32,50.88) v1(11.32,49.61) v1(11.32,48.34) v1(11.32,47.07) v1(11.32,45.8) v1(11.32,44.53) v1(11.31,43.32) v1(11.3,42.11) v1(11.28,40.9) v1(11.52,121.93) v1(11.52,121.14) v1(11.52,118.8) v1(11.53,115.91) v1(11.62,6.07) v1(11.74,32.43) v1(11.74,31.51) v1(11.76,112.41) v1(12.17,75.51) v1(12.24,54.69) v1(12.24,53.42) v1(12.24,52.15) v1(12.24,50.88) v1(12.24,49.61) v1(12.24,48.34) v1(12.24,47.07) v1(12.24,45.8) v1(12.22,43.32) v1(12.21,42.11) v1(12.2,40.9) v1(12.7,154.19) v1(12.65,32.43) v1(12.65,31.51) v1(12.89,6.07) v1(13.56,32.43) v1(13.56,31.51) v1(14.23,154.19) v1(14.16,6.07) v1(14.25,153.7) v1(14.3,34.94) v1(14.45,82.33) v1(14.45,81.32) v1(14.45,80.3) v1(14.45,79.28) v1(14.45,78.27) v1(14.45,77.35) v1(14.48,31.51) v1(14.81,133.9) v1(14.81,133.09) v1(15.4,20.56) v1(15.43,6.07) v1(15.46,82.33) v1(15.46,81.32) v1(15.46,80.3) v1(15.46,79.28) v1(15.46,78.27) v1(15.46,77.35) v1(15.72,133.09) v1(15.75,154.19) v1(16.07,88.12) v1(16.07,87.35) v1(16.07,85.44) v1(16.12,72.27) v1(16.12,71.66) v1(16.53,90.78) v1(16.53,90.15) v1(16.53,89.36) v1(16.53,88.88) v1(16.48,82.33) v1(16.48,81.32) v1(16.48,80.3) v1(16.48,79.28) v1(16.48,78.27) v1(16.48,77.35) v1(16.53,70.78) v1(16.53,70.02) v1(16.53,69.26) v1(16.52,60.63) v1(16.7,6.07) v1(16.93,73.28) v1(16.99,88.12) v1(16.99,87.35) v1(16.99,85.44) v1(17.01,72.6) v1(17.01,71.99) v1(17.01,71.33) v1(17.27,154.19) v1(17.44,90.78) v1(17.44,90.15) v1(17.44,89.36) v1(17.44,88.88) v1(17.44,70.78) v1(17.44,70.02) v1(17.44,69.26) v1(17.43,37.49) v1(17.43,36.63) v1(17.5,82.33) v1(17.5,81.32) v1(17.5,80.3) v1(17.5,79.28) v1(17.5,78.27) v1(17.5,77.35) v1(17.9,88.12) v1(17.9,87.35) v1(17.9,85.44) v1(17.9,72.24) v1(17.93,71.66) v1(17.97,6.07) v1(18.06,36.63) v1(18.41,119.05) v1(18.41,118.04) v1(18.41,117.02) v1(18.41,116.01) v1(18.41,114.99) v1(18.51,82.33) v1(18.51,81.32) v1(18.51,80.3) v1(18.51,79.28) v1(18.51,78.27) v1(18.8,154.19) v1(18.81,29.27) v1(18.81,28.31) v1(18.93,37.49) v1(18.93,36.63) v1(19.22,94.06) v1(19.24,6.07) v1(19.3,53.75) v1(19.43,119.05) v1(19.43,118.04) v1(19.43,117.02) v1(19.43,116.01) v1(19.43,114.99) v1(19.53,82.33) v1(19.53,81.32) v1(19.53,80.3) v1(19.53,79.28) v1(19.53,78.27) v1(19.77,29.27) v1(19.77,28.31) v1(19.98,46.4) v1(19.98,45.16) v1(19.98,43.91) v1(20.21,53.75) v1(20.21,52.73) v1(20.32,154.19) v1(20.44,119.05) v1(20.44,118.04) v1(20.44,117.02) v1(20.44,116.01) v1(20.44,114.99) v1(20.51,6.07) v1(20.74,29.27) v1(20.74,28.31) v1(20.95,46.4) v1(20.95,45.16) v1(20.95,43.91) v1(20.95,42.67) v1(21.46,119.05) v1(21.46,118.04) v1(21.46,117.02) v1(21.46,116.01) v1(21.46,114.99) v1(21.5,29.27) v1(21.5,28.31) v1(21.85,154.19) v1(21.78,6.07) v1(21.91,47.64) v1(21.91,46.4) v1(21.91,45.16) v1(21.91,43.91) v1(21.91,42.67) v1(22.48,118.04) v1(22.48,117.02) v1(22.48,114.99) v1(22.88,46.4) v1(22.88,43.91) v1(23.05,6.07) v1(23.37,154.19) v1(23.87,67.09) v1(24.33,66.73) v1(24.32,6.07) v1(24.76,67.11) v1(24.89,154.19) v1(25.55,52.81) v1(25.55,52.18) v1(25.59,6.07) v1(26.42,154.19) v1(26.47,40.16) v1(26.57,52.81) v1(26.57,52.18) v1(26.68,49.2) v1(27.18,44.03) v1(27.18,43.11) v1(27.44,40.16) v1(27.67,68.66) v1(27.67,67.75) v1(27.69,49.2) v1(27.69,48.29) v1(27.77,28.46) v1(27.77,27.49) v1(27.94,154.19) v1(28.15,44.03) v1(28.15,43.11) v1(28.13,6.07) v1(28.4,40.16) v1(28.48,81.22) v1(28.5,79.8) v1(28.71,49.2) v1(28.71,48.29) v1(28.74,28.46) v1(28.74,27.49) v1(29.11,44.03) v1(29.11,43.11) v1(29.47,154.19) v1(29.62,53.15) v1(29.62,52.18) v1(29.72,49.2) v1(30.63,53.15) v1(30.63,52.18) v1(30.99,154.19) v1(32.51,154.19) v1(33.21,6.07) v1(33.27,46.63) v1(33.27,45.61) v1(33.27,44.59) v1(34.04,154.19) v1(34.28,45.61) v1(34.28,44.59) v1(35.3,46.63) v1(35.3,45.61) v1(35.3,44.59) v1(35.48,97.27) v1(35.56,154.19) v1(35.75,6.07) v1(36.09,24.99) v1(37.09,154.19) v1(37.08,97.26) v1(37.1,32.5) v1(37.1,31.33) v1(37.1,30.16) v1(37.53,86.86) v1(37.86,31.91) v1(37.86,30.74) v1(37.86,29.58) v1(38.62,32.5) v1(38.62,31.33) v1(38.62,30.16) v1(38.71,79.16) v1(39.16,154.19) v1(39.43,20.43) v1(39.48,86.58) v1(40.11,79.13) v1(41.22,42.87) v1(41.22,41.9) v1(41.22,40.94) v1(41.43,86.86) v1(41.64,151.54) v1(41.64,150.78) v1(41.64,150.02) v1(42.19,42.87) v1(42.19,41.9) v1(42.19,40.94) v1(42.4,151.54) v1(42.4,150.78) v1(42.4,150.02) v1(42.67,69.98) v1(43.16,151.54) v1(43.16,150.78) v1(43.16,150.02) v1(43.22,58.29) v1(43.22,57.43) v1(43.15,42.87) v1(43.15,41.9) v1(43.15,40.94) v1(43.37,6.07) v1(43.58,69.98) v1(43.93,32.19) v1(43.93,31.23) v1(43.93,30.26) v1(43.93,29.3) v1(44.08,58.29) v1(44.64,6.07) v1(44.95,58.29) v1(44.95,57.43) v1(44.9,32.19) v1(44.9,31.23) v1(44.9,30.26) v1(44.9,29.3) v1(45.81,58.29) v1(45.78,11.31) v1(45.86,32.19) v1(45.86,31.23) v1(45.86,30.26) v1(45.86,29.3) v1(45.91,6.07) v1(46.5,56.33) v1(46.5,54.83) v1(46.69,80.05) v1(46.68,58.29) v1(46.7,11.31) v1(46.83,32.19) v1(46.83,31.23) v1(46.83,30.26) v1(47.18,6.07) v1(47.43,7.55) v1(47.92,11.14) v1(48.34,7.55) v1(48.45,6.07) v1(48.54,81.19) v1(48.73,151.34) v1(48.73,150.32) v1(48.73,149.31) v1(48.73,148.29) v1(48.66,145.28) v1(49.6,82.54) v1(49.75,151.34) v1(49.75,150.32) v1(49.75,149.31) v1(49.75,148.29) v1(49.72,6.07) v1(49.82,10.53) v1(49.93,106.86) v1(50.74,10.53) v1(50.76,151.34) v1(50.76,150.32) v1(50.76,149.31) v1(50.76,148.29) v1(50.99,6.07) v1(51.53,11.57) v1(51.71,28.71) v1(51.78,151.34) v1(51.78,150.32) v1(51.78,149.31) v1(51.78,148.29) v1(52.44,142.45) v1(52.44,140.78) v1(53.04,87.83) v1(52.97,83.73) v1(53,44.31) v1(53,43.34) v1(53,42.38) v1(53,41.41) v1(53.07,141.62) v1(53.16,11.57) v1(53.27,154.19) v1(53.71,140.78) v1(53.71,31.99) v1(53.71,30.82) v1(53.71,29.65) v1(53.97,44.31) v1(53.97,43.34) v1(53.97,42.38) v1(53.97,41.41) v1(54.34,141.62) v1(54.27,8.39) v1(54.27,7.63) v1(54.49,107.02) v1(54.47,85.01) v1(54.47,32.57) v1(54.47,31.4) v1(54.47,30.24) v1(54.79,154.19) v1(54.93,44.31) v1(54.93,43.34) v1(54.93,42.38) v1(54.93,41.41) v1(54.98,142.45) v1(54.96,136.79) v1(55.23,31.99) v1(55.23,30.82) v1(55.23,29.65) v1(55.69,52.23) v1(55.9,44.31) v1(55.9,43.34) v1(55.9,41.41) v1(56.12,84.95) v1(56.31,154.19) v1(57.01,107.03) v1(56.96,105.08) v1(57.1,103.33) v1(57.84,154.19) v1(57.9,85.14) v1(57.9,73.21) v1(58.03,109.84) v1(58.03,87.28) v1(58.61,115.16) v1(58.61,92.61) v1(59.36,154.19) v1(59.38,105.64) v1(59.75,96.04) v1(59.75,94.89) v1(59.75,93.75) v1(59.75,92.61) v1(59.99,142.37) v1(60.29,153.76) v1(60.29,152.85) v1(60.26,119.74) v1(60.26,118.59) v1(60.26,117.45) v1(60.26,116.31) v1(60.26,115.16) v1(60.89,154.19) v1(60.9,144.2) v1(60.9,143.28) v1(60.9,142.37) v1(60.9,96.04) v1(60.9,94.89) v1(60.9,93.75) v1(60.9,92.61) v1(61.15,6.07) v1(61.21,153.76) v1(61.21,152.85) v1(61.28,119.74) v1(61.28,118.59) v1(61.28,117.45) v1(61.28,116.31) v1(61.28,115.16) v1(61.74,106.14) v1(61.8,136.91) v1(61.75,104.25) v1(62,152.06) v1(62,151.14) v1(62.04,97.18) v1(62.04,96.04) v1(62.04,94.89) v1(62.04,93.75) v1(62.04,92.61) v1(62.05,141.52) v1(62.08,79.15) v1(62.08,76.81) v1(62.29,119.74) v1(62.29,118.59) v1(62.29,117.45) v1(62.29,116.31) v1(62.29,115.16) v1(62.41,154.19) v1(62.42,6.07) v1(63.11,137.59) v1(63.24,132.74) v1(63.18,96.04) v1(63.18,93.75) v1(63.18,92.61) v1(63.31,119.74) v1(63.31,118.59) v1(63.31,117.45) v1(63.31,116.31) v1(63.31,115.16) v1(63.27,86.73) v1(63.27,86.09) v1(63.69,6.07) v1(63.93,154.19) v1(63.91,106.4) v1(64.03,139.73) v1(64.54,135.84) v1(64.96,6.07) v1(65.13,145.01) v1(65.1,127) v1(65.46,154.19) v1(65.82,134.65) v1(65.82,133.82) v1(66.09,147.3) v1(66.23,6.07) v1(66.6,141.56) v1(66.83,131.28) v1(66.91,128.88) v1(66.98,154.19) v1(66.99,134.65) v1(66.99,133.82) v1(66.99,132.98) v1(67.15,126.8) v1(67.36,34.28) v1(67.5,64.08) v1(67.5,6.07) v1(67.57,147.3) v1(67.75,144.91) v1(67.69,138.92) v1(67.71,66.26) v1(68.06,141.56) v1(68.09,129.84) v1(68.16,134.65) v1(68.16,133.82) v1(68.16,132.98) v1(68.18,123.7) v1(68.38,128.65) v1(68.51,154.19) v1(68.77,6.07) v1(69.04,147.3) v1(69,126.27) v1(69.03,48.12) v1(69.03,47.46) v1(69.14,138.83) v1(69.33,134.65) v1(69.33,133.82) v1(69.33,132.98) v1(69.33,131.28) v1(69.61,141.5) v1(69.84,128.65) v1(69.95,145.02) v1(69.94,48.12) v1(69.94,47.46) v1(70.03,154.19) v1(70.04,6.07) v1(70.49,134.65) v1(70.49,133.82) v1(70.49,132.98) v1(70.58,147.3) v1(70.65,137.49) v1(71.05,40.78) v1(71.11,63.43) v1(71.11,61.71) v1(71.24,139.05) v1(71.16,127.8) v1(71.31,6.07) v1(71.44,130.06) v1(71.5,137.49) v1(71.55,154.19) v1(71.64,85) v1(71.64,84.08) v1(71.64,83.17) v1(71.66,134.65) v1(71.66,133.82) v1(71.66,132.98) v1(71.86,107.51) v1(71.86,106.6) v1(71.86,105.68) v1(71.99,147.3) v1(71.96,74.87) v1(72.24,144.92) v1(72.47,85.37) v1(72.47,82.8) v1(72.61,129.57) v1(72.61,127.23) v1(72.58,6.07) v1(72.68,107.88) v1(72.7,49.76) v1(72.7,48.61) v1(72.7,47.47) v1(72.7,46.33) v1(72.83,134.65) v1(72.83,133.82) v1(72.83,132.98) v1(72.88,74.84) v1(73.05,139.58) v1(73.08,154.19) v1(73.07,153.18) v1(73.13,152.19) v1(73.33,85.37) v1(73.33,82.8) v1(73.39,141.6) v1(73.61,11.52) v1(73.61,10) v1(73.84,49.76) v1(73.84,48.61) v1(73.84,47.47) v1(73.84,46.33) v1(73.85,6.07) v1(73.86,153.47) v1(74.09,34.84) v1(74.16,53.12) v1(74.41,136.37) v1(74.41,9.23) v1(74.6,154.19) v1(74.86,12) v1(74.98,49.76) v1(74.98,48.61) v1(74.98,47.47) v1(74.98,46.33) v1(75.12,6.07) v1(75.23,137.75) v1(75.24,37.33) v1(75.26,137.07) v1(75.27,136.37) v1(75.45,140.61) v1(75.56,17.83) v1(75.72,40.63) v1(75.83,25.26) v1(75.83,24.24) v1(75.83,23.23) v1(75.91,146.87) v1(76.13,154.19) v1(76.05,145.04) v1(76.12,49.76) v1(76.12,48.61) v1(76.12,47.47) v1(76.12,46.33) v1(76.2,42.13) v1(76.39,6.07) v1(76.81,38.01) v1(76.85,25.26) v1(76.85,23.23) v1(76.94,135.67) v1(76.86,36.01) v1(77.37,40.53) v1(77.65,154.19) v1(77.66,6.07) v1(78.2,145.45) v1(78.46,39.33) v1(78.46,38.44) v1(78.46,37.55) v1(78.93,6.07) v1(79.17,154.19) v1(79.38,63.1) v1(79.38,62.18) v1(79.66,25.29) v1(79.66,24.37) v1(80.2,6.07) v1(80.29,63.1) v1(80.29,62.18) v1(80.37,45.17) v1(80.37,43.5) v1(80.39,32.4) v1(80.44,29.93) v1(80.57,40.68) v1(80.57,24.37) v1(80.7,154.19) v1(80.75,151.93) v1(80.8,23.61) v1(81,51.19) v1(81.13,36.16) v1(81.36,62.18) v1(81.71,23.61) v1(82.12,33.74) v1(82.15,31.15) v1(82.22,154.19) v1(82.22,42.89) v1(82.27,62.18) v1(82.74,6.07) v1(83.03,63.86) v1(83.03,62.94) v1(83.75,154.19) v1(84.01,152.91) v1(84.01,151.38) v1(84.01,149.86) v1(84.01,148.34) v1(84.01,146.81) v1(84.01,145.29) v1(84.01,143.76) v1(84.01,142.24) v1(84.01,140.72) v1(84.01,139.19) v1(84.01,137.67) v1(84.01,136.14) v1(84.01,134.62) v1(84.01,133.1) v1(84.01,131.57) v1(84.01,105.66) v1(84.01,83.97) v1(84.01,82.45) v1(84.01,80.92) v1(84.01,63.78) v1(84.01,62.51) v1(84.01,60.98) v1(84.01,59.46) v1(84.01,57.94) v1(84.01,56.41) v1(84.01,54.89) v1(84.01,53.36) v1(84.01,51.84) v1(84.01,48.79) v1(84.01,47.27) v1(84.01,45.74) v1(84.01,44.22) v1(84.01,42.7) v1(84.01,41.17) v1(84.01,36.6) v1(84.01,35.08) v1(84.01,33.55) v1(84.01,32.03) v1(84.01,30.5) v1(84.01,28.98) v1(84.01,27.46) v1(84.01,25.93) v1(84.01,24.41) v1(84.01,7.59) v1(84.01,6.07)
