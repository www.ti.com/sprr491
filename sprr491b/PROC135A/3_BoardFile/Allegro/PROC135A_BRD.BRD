# Allegro board PROC135A_BRD.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BOOTMODEON: length 45.8
  TOP w0.14: v1(69.21,24.79) 69.42,25.01 R221.2 71.27,26.18 71.45,26.36 U45.4
  L05_SIG02 w0.102: v1(69.21,24.79) 68.71,25.29 66.7,25.29 65.9,26.09 60.69,26.09 v1(57.13,29.65)
  L10_SIG03 w0.102: v1(57.13,29.65) 55.42,31.36 55.1,31.36 53.9,32.55 52.91,32.55 52.33,33.14 43.84,33.14 43.21,32.5 41.48,32.5 40.82,33.16 36.65,33.16 35.99,32.49 v1(34.5,32.49)
  BOTTOM w0.14: v1(34.5,32.49) U101.22 ; U98.22 v1(57.13,29.65)
BT_EN_SOC: length 177.7
  TOP w0.14: J2.54 8.01,147.79 v1(7.79,147.57)
  L03_SIG01 w0.102: v1(16.79,39.99) 16.47,39.67 15.37,39.67 14.31,40.73 14.31,54.64 11.27,57.68 8.72,57.68 7.17,59.23 v1(6.35,59.23)
  L05_SIG02 w0.102: v1(7.79,147.57) 9.84,145.52 9.84,136.23 11.94,134.13 11.94,132.83 v1(11.96,132.81)
  L10_SIG03 w0.102: v1(6.35,59.23) 1.94,59.23 1.34,59.83 1.34,64.64 2.29,65.59 2.29,71.21 3.81,72.73 4.4,72.73 7.37,75.71 7.37,80.81 7.8,81.24 7.8,84.09 4.68,87.21 4.24,87.21 3.76,87.69 3.76,89.96 3.88,90.08 3.88,91.49 3.52,91.85 3.52,92.71 5.48,94.67 5.48,98.69 5.69,98.91 5.69,105.14 5.26,105.58 5.26,108.19 7.85,110.78 7.85,121.3 9.65,123.1 9.65,125.6 7.82,127.42 7.82,131.36 9.28,132.81 v1(11.96,132.81) ; v1(16.79,39.99) 17.14,39.99 17.75,39.38 19.6,39.38 19.73,39.52 21.55,39.52 22.09,38.98 23.56,38.98 23.71,38.82 29.7,38.82 29.91,38.62 35.62,38.62 36.51,39.51 36.51,40.71 38.85,43.05 40.17,43.05 40.78,43.66 44.87,43.66 46.42,42.11 v1(47.93,42.11)
  BOTTOM w0.14: v1(7.79,147.57) 7.29,148.08 R250.1 ; v1(47.93,42.11) 49.05,41 50.18,41 51.3,42.11 U92.3
BT_UART_WAKE_SOC_1V8: length 44.6
  TOP w0.14: U1.3 v1(41.9,148.2) ; v1(11.72,144.13) 14.27,141.59 14.27,140.36 14.11,140.21 13.87,140.21 13.28,139.62 R25.2
  L05_SIG02 w0.102: v1(41.9,148.2) 41.24,148.86 39.16,148.86 37.41,150.62 29.1,150.62 26.78,148.3 11.28,148.3 10.83,147.86 10.83,145.02 v1(11.72,144.13)
BT_UART_WAKE_SOC_3V3: length 183.8
  TOP w0.14: v1(11.7,143.17) 11.5,142.97 11.5,140.77 11.71,140.56 R22.1 R24.2 ; U1.12 41.9,153.24 41.76,153.38 v1(41.47,153.38)
  L03_SIG01 w0.102: v1(41.47,153.38) 41.47,152.76 40.66,151.95 40.66,148.9 40.95,148.6 40.95,144.04 45.78,139.21 47.47,139.21 52.02,134.66 57.42,134.66 v1(58.48,133.6)
  L05_SIG02 w0.102: v1(11.7,143.17) 10.51,144.36 10.51,148.26 12.06,149.81 27.41,149.81 29.39,151.78 40.72,151.78 41.47,152.53 v1(41.47,153.38) ; v1(62.02,51.54) 63.95,51.54 65.36,52.95 66.35,52.95 67.44,54.04 67.44,63.18 66.6,64.02 66.6,68.24 67.34,68.97 67.34,77.83 66.66,78.5 66.66,89.97 65.71,90.91 65.71,98.74 66.37,99.4 66.37,102.91 66.8,103.34 66.8,105.84 67.32,106.35 67.32,107.43 66.82,107.93 66.82,111.23 66.52,111.53 66.52,112.31 66.19,112.64 66.19,115.58 66.45,115.85 66.45,125.29 65.62,126.12 65.62,130.25 64.75,131.12 64.75,132.25 62.38,134.61 59.49,134.61 v1(58.48,133.6)
  BOTTOM w0.14: v1(62.02,51.54) 57.6,51.54 54.2,48.14 U92.12
BT_UART_WAKE_SOC_R: length 2.8
  TOP w0.14: R25.1 R24.1 11.88,139.06 11.65,139.29 J2.20
BT_WLAN_EN: length 37.5
  TOP w0.14: v1(43.05,146.87) 42.73,146.87 42.59,147.01 R10.1 R11.2 ; J2.56 11.21,148.29 v1(11.64,147.86)
  L05_SIG02 w0.102: v1(11.64,147.86) 26.76,147.86 29.23,150.34 37.16,150.34 39.71,147.79 42.07,147.79 43,146.87 v1(43.05,146.87)
BUF_BOOTMODE_I2C1_SCL: length 2.1
  TOP w0.14: U47.82 61.57,24.71 v1(61.35,24.93)
  BOTTOM w0.14: R614.1 61.41,24.87 v1(61.35,24.93)
BUF_BOOTMODE_I2C1_SDA: length 2.1
  TOP w0.14: v1(62.19,24.93) 61.97,24.71 U47.81
  BOTTOM w0.14: R615.1 62.17,24.92 v1(62.19,24.93) 62.23,24.89
BUF_BOOTMODE_I2C_SCL: length 35.3
  TOP w0.14: v1(68.59,16.23) U47.49
  L03_SIG01 w0.102: v1(68.59,16.23) 70.55,18.19 71.57,18.19 73.44,20.06 73.44,23.35 74.63,24.54 74.63,27.49 73.33,28.79 73.33,32.25 72.64,32.95 68.19,32.95 66.35,31.1 62.34,31.1 v1(62.23,31.22)
  BOTTOM w0.14: U99.2 62.33,31.12 v1(62.23,31.22) R479.2
BUF_BOOTMODE_I2C_SDA: length 35
  TOP w0.14: U47.50 71,16.63 v1(71.22,16.85)
  L03_SIG01 w0.102: v1(61.92,32.64) 62.43,32.13 65.46,32.13 66.64,33.3 73.2,33.3 73.88,32.62 73.88,31.83 74.96,30.75 74.96,24.39 73.75,23.18 73.75,19.38 v1(71.22,16.85)
  BOTTOM w0.14: v1(61.92,32.64) 61.75,32.46 R477.2 62.78,32.11 63.06,32.39 U99.3
BUF_TEST_GPIO1: length 3.9
  TOP w0.14: U47.74 64.77,25.91 64.2,26.48 U44.1
BUF_TEST_GPIO2: length 6.8
  TOP w0.14: v1(65.22,25.27) 65.17,25.22 U47.73
  BOTTOM w0.14: v1(65.22,25.27) 65.26,25.31 65.26,25.88 63.95,27.19 63.95,27.84 63.69,28.1 62.86,28.1 62.75,27.99 U102.2
BUF_TEST_GPIO3: length 4
  TOP w0.14: U47.72 65.57,24.83 65.67,24.93 65.67,25.68 65,26.34 U44.3
BUF_TEST_GPIO4: length 3.7
  TOP w0.14: U44.5 65.8,26.54 65.97,26.38 U47.71
BUF_TEST_PORZN: length 11.6
  TOP w0.14: v1(66.2,31.92) U44.9 ; v1(65.09,31.65) 63.07,29.63 63.07,27.04 62.91,26.88 62.91,25.68 63.57,25.03 U47.77
  BOTTOM w0.14: v1(65.09,31.65) 65.93,31.65 v1(66.2,31.92)
BUF_TEST_POWERDOWN: length 10.9
  TOP w0.14: U44.13 64.6,32.17 62.18,29.74 62.18,25.83 63.17,24.84 U47.78
BUF_TEST_WARMRESETN: length 11
  TOP w0.14: U47.76 63.97,25.11 63.57,25.51 63.57,26.16 63.85,26.44 63.85,26.98 63.37,27.46 63.37,29.24 65.63,31.5 65.63,32.06 65.4,32.28 U44.11
CAN_FD_WKUP_HDR_INH: length 47.5
  TOP w0.14: v1(13.44,101.97) 13.44,103.37 R75.1
  L05_SIG02 w0.102: J8.5 18.33,63.27 18.33,65.27 18.81,65.75 18.81,67.14 v1(19.4,67.73)
  L10_SIG03 w0.102: v1(19.4,67.73) 18.47,66.8 17.55,66.8 15.38,68.97 15.38,74.04 14.86,74.56 14.86,82.67 13.55,83.97 13.55,93.54 14.1,94.09 14.1,96.09 13.84,96.35 13.84,100.33 13.44,100.72 v1(13.44,101.97)
CAN_FD_WKUP_SW_INH: length 49.3
  TOP w0.14: R82.2 15.45,101.71 v1(15.55,101.61) ; U35.7 v1(9.85,59.52)
  L03_SIG01 w0.102: v1(9.85,59.52) 9.06,60.31 9.06,64.46 8.77,64.76 8.77,83.96 9.88,85.08 9.88,90.72 11.12,91.96 14.58,91.96 16.16,93.53 16.16,101.05 15.6,101.61 v1(15.55,101.61)
CAN_IO_3V3: length 129.3
  TOP w0.254: U35.8 C104.1 v1(9.85,61.45) ; R65.1 11.75,105.72 11.04,106.43 7.65,106.43 v1(7.34,106.73) ; R149.1 v1(10,56.21) ; R139.2 3.69,65.72 v1(4.75,65.72)
  TOP w0.356: U18.H8 v1(36.28,100.47)
  TOP w0.381: R140.2 v1(4.75,65.11)
  L07_PWR02 w0.381: v1(22.36,68.14) 21.48,67.27 21.48,66.63 21.1,66.25 13.05,66.25 11.91,65.11 v1(4.75,65.11)
  L08_PWR03 w0.165: 31.18,100.86 35.88,100.86 v1(36.28,100.47) 35.88,100.07 31.17,100.07 30.78,100.46 30.78,100.47 31.18,100.86
  L08_PWR03 w0.381: v1(28.1,99.48) 29.09,100.47 30.78,100.47
  L10_SIG03 w0.254: v1(7.34,106.73) 7.34,104.9 7.52,104.72 7.52,96.27 7.27,96.01 7.27,95.33 5.93,93.99 5.93,91.86 6.19,91.6 6.19,90.75 6.08,90.64 6.08,90.26 6.19,90.16 6.19,89.22 6.04,89.07 6.04,87.18 8.56,84.66 8.56,73.21 4.45,69.09 4.45,66.03 v1(4.75,65.72)
  L10_SIG03 w0.305: v1(28.1,99.48) 27.31,99.48 26.01,98.18 26.01,97.58 25.35,96.93 25.35,94.84 24.91,94.39 24.91,87.66 24.09,86.84 24.09,70.37 22.85,69.13 22.85,68.64 v1(22.36,68.14)
  BOTTOM w0.254: v1(28.1,99.48) C282.1 C283.1 ; R535.1 25.03,18.48 25.86,18.48 v1(26.47,17.87) ; R523.1 32.95,20.43 v1(32.82,20.56)
CAP_VDDS0: length 0.8
  TOP w0.254: U18.G13 v1(35.48,105.26)
  BOTTOM w0.381: C241.1 v1(35.48,105.26)
CAP_VDDS1: length 0.8
  TOP w0.254: U18.K16 v1(37.88,107.66)
  BOTTOM w0.305: C222.1 37.74,107.8 v1(37.88,107.66)
CAP_VDDS2: length 0.8
  TOP w0.254: U18.T14 v1(43.48,106.06)
  BOTTOM w0.305: v1(43.48,106.06) 43.55,106.13 C235.1
CAP_VDDS3: length 0.9
  TOP w0.254: U18.M16 v1(40.28,107.66)
  BOTTOM w0.305: C220.1 40.4,107.79 v1(40.28,107.66)
CAP_VDDS4: length 0.9
  TOP w0.254: U18.R8 v1(42.68,100.47)
  BOTTOM w0.305: 42.88,100.26 v1(42.68,100.47)
CAP_VDDS5: length 0.7
  TOP w0.254: U18.G15 v1(35.48,106.86)
  BOTTOM w0.305: C231.1 v1(35.48,106.86)
CAP_VDDS6: length 0.8
  TOP w0.254: U18.J16 v1(37.08,107.66)
  BOTTOM w0.305: v1(37.08,107.66) 37.07,107.65 C223.1
CAP_VDDS_CANUART: length 0.9
  TOP w0.254: U18.G8 v1(35.48,100.47)
  BOTTOM w0.254: C287.1 35.6,100.34 v1(35.48,100.47)
CAP_VDDS_MCU: length 0.9
  TOP w0.254: U18.G10 v1(35.48,102.07)
  BOTTOM w0.305: C264.1 35.43,102.07 v1(35.48,102.07)
CLKOUT0: length 2.5
  TOP w0.14: U7.1 51.1,136.38 50.51,136.97 R28.2 R27.2
CLKOUT_OSC: length 1.4
  TOP w0.14: R27.1 U6.3
COM_SDIO_CLK: length 34.1
  TOP w0.14: v1(1.35,136.72) 1.52,136.54 J2.9
  L10_SIG03 w0.102: v1(1.35,136.72) 0.85,137.21 0.85,139.93 3.26,142.33 6.39,142.33 9.28,145.23 15.94,145.23 v1(23.98,153.26)
  BOTTOM w0.14: v1(23.98,153.26) 24.16,153.09 R243.1
COM_SDIO_CMD: length 34
  TOP w0.14: v1(1.31,137.73) 1.31,137.41 1.68,137.04 J2.11
  L10_SIG03 w0.102: v1(19.03,139.68) 19.03,141.19 16.57,143.65 16.38,143.65 16.21,143.49 16.21,143.33 18.54,141 18.54,140.79 18.36,140.61 18.13,140.61 15.09,143.65 11.36,143.65 9.06,141.35 3.31,141.35 1.97,140.01 1.97,138.38 v1(1.31,137.73)
  BOTTOM w0.14: R267.1 18.61,139.26 v1(19.03,139.68)
COM_SDIO_D0: length 34
  TOP w0.14: v1(3.91,137.35) 3.72,137.54 J2.13
  L10_SIG03 w0.102: v1(13.95,139.68) 14.4,140.13 14.4,142.45 14.2,142.65 12.09,142.65 11.97,142.53 11.97,142.36 12.09,142.24 13.5,142.24 13.62,142.12 13.62,141.96 13.5,141.84 12.09,141.84 11.97,141.72 11.97,141.55 12.09,141.43 13.37,141.43 13.49,141.31 13.49,141.14 13.37,141.02 11.69,141.02 11.57,141.14 11.57,142.3 11.46,142.4 10.98,142.4 10.86,142.29 10.86,141.1 10.73,140.96 3.48,140.96 2.38,139.86 2.38,139.54 2.5,139.42 2.93,139.42 3.05,139.3 3.05,139.13 2.93,139.01 2.5,139.01 2.38,138.89 2.38,138.72 2.5,138.61 2.93,138.61 3.05,138.49 3.05,138.32 2.93,138.2 2.5,138.2 2.38,138.08 2.38,137.55 2.58,137.35 v1(3.91,137.35)
  BOTTOM w0.14: R269.1 13.53,139.26 v1(13.95,139.68)
COM_SDIO_D1: length 34
  TOP w0.14: J2.15 3.65,138.04 v1(3.85,138.24)
  L10_SIG03 w0.102: v1(16.49,139.68) 16.07,139.26 15.35,139.26 15.23,139.38 15.23,139.55 15.35,139.67 15.75,139.67 15.87,139.79 15.87,139.95 15.75,140.07 15.35,140.07 15.23,140.19 15.23,140.36 15.35,140.48 15.73,140.48 15.85,140.6 15.85,140.77 15.73,140.89 15.35,140.89 15.23,141.01 15.23,141.17 15.35,141.29 15.75,141.29 15.87,141.41 15.87,141.58 15.75,141.7 14.94,141.7 14.82,141.58 14.82,139.38 14.71,139.26 12.54,139.26 11.19,140.62 7.64,140.62 7.53,140.5 7.53,140.33 7.64,140.21 10.61,140.21 10.73,140.1 10.73,139.93 10.6,139.8 7.24,139.8 7.12,139.92 7.12,140.5 7,140.62 3.66,140.62 3.35,140.31 3.35,138.74 v1(3.85,138.24)
  BOTTOM w0.14: R268.1 16.07,139.26 v1(16.49,139.68)
COM_SDIO_D2: length 34.1
  TOP w0.14: v1(1.32,138.81) 1.59,138.54 J2.17
  L10_SIG03 w0.102: v1(26.65,139.68) 23.59,142.73 23.4,142.73 23.3,142.64 23.11,142.64 22.98,142.77 22.98,142.96 23.08,143.06 23.08,143.25 22.94,143.38 22.75,143.38 22.66,143.29 22.47,143.29 22.33,143.42 22.33,143.61 22.43,143.7 22.43,143.89 21.62,144.7 9.27,144.7 6.55,141.98 3.41,141.98 1.32,139.9 v1(1.32,138.81)
  BOTTOM w0.14: v1(26.65,139.68) 26.23,139.26 R266.1
COM_SDIO_D3: length 34.1
  TOP w0.14: J2.19 v1(3.84,139.04)
  L10_SIG03 w0.102: v1(29.19,139.68) 28.43,138.91 26.08,138.91 25.94,139.05 25.94,139.58 25.81,139.71 25.62,139.71 25.49,139.58 25.49,139.05 25.35,138.91 25.16,138.91 25.03,139.05 25.03,139.58 24.9,139.71 24.71,139.71 24.57,139.58 24.57,139.05 24.44,138.91 22.84,138.91 22.71,139.05 22.71,139.64 22.56,139.78 22.37,139.78 22.25,139.65 22.25,139.05 22.11,138.91 20.54,138.91 20.4,139.05 20.4,139.8 20.27,139.93 20.08,139.93 19.95,139.8 19.95,139.05 19.81,138.91 12.16,138.91 11.7,139.37 4.17,139.37 v1(3.84,139.04)
  BOTTOM w0.14: v1(29.19,139.68) 28.77,139.26 R265.1
COMP_LM5141: length 4.1
  BOTTOM w0.14: U89.20 35.03,42.85 35.52,42.36 36.1,42.36 R441.1 36.6,41.32 36.45,41.17 C433.1
CONN_MCU_PORZ: length 46.7
  L03_SIG01 w0.102: v1(55.88,35.99) 56.37,36.47 56.37,37.87 55.24,38.99 53.41,38.99 52.9,39.5 51.96,39.5 51.58,39.88 50.59,39.88 49.16,41.31 47.94,41.31 47.39,41.86 47.39,44.04 47.86,44.51 47.86,46.53 47.22,47.16 47.22,50.05 53.68,56.51 53.68,63.08 53.42,63.34 v1(53.42,64.82)
  L10_SIG03 w0.102: J8.28 49.96,64.76 50.59,65.39 52.85,65.39 v1(53.42,64.82)
  BOTTOM w0.14: R465.1 55.24,35.99 v1(55.88,35.99) U96.1
CONN_MCU_RESETZ: length 25.1
  TOP w0.14: v1(44.02,42.83) 44.02,42.43 45.38,41.07 Q3.1
  L03_SIG01 w0.102: v1(44.02,42.83) 44.02,46.83 44.26,47.07 44.26,54.89 44.52,55.14 44.52,59.83 44.79,60.1 J8.25
  BOTTOM w0.14: R390.1 J8.25
CORE_PWR_STRAP: length 16.4
  TOP w0.14: U27.24 v1(15.74,84.58)
  BOTTOM w0.14: v1(15.74,84.58) 15.74,82.89 15.58,82.73 14.75,82.73 9.7,87.79 9.7,88.42 9.26,88.85 7.39,88.85 7.29,88.76 6.92,88.76 5.99,89.69 R618.1 R619.2
CPSW1_GPIO_0: length 4.2
  BOTTOM w0.14: Q7.1 R367.1
  BOTTOM w0.254: J6.14 82.88,85.86 82.82,85.81 Q7.6
CPSW1_LED_1000: length 3.4
  BOTTOM w0.254: Q5.2 82.6,103.87 82.88,103.59 J6.12
CPSW1_LED_ACT: length 4.4
  BOTTOM w0.14: Q6.1 R366.1
  BOTTOM w0.254: J6.13 80.85,86.36 80.16,85.67 Q6.6
CPSW2_GPIO_0: length 6.4
  BOTTOM w0.14: J24.14 82.49,110.08 82.49,108.74 81.1,107.35 U127.6 ; U127.1 R589.1
CPSW2_LED_1000: length 7.3
  BOTTOM w0.14: J24.12 82.88,125.14 81.65,126.37 79.57,126.37 78.99,126.95 77.54,126.95 U128.1
CPSW2_LED_ACT: length 21.7
  L03_SIG01 w0.102: v1(67.71,109.05) 67.71,107.8 70.66,104.86 78.96,104.86 79.98,105.87 79.98,109.6 J24.13
  BOTTOM w0.14: U126.6 v1(67.71,109.05) ; U126.1 R590.1
CPSW_ETH1_D0N: length 10.2
  BOTTOM w0.089: J6.10 71.03,99.42 71.03,98.7 70.08,97.76 68.53,97.76 67.87,98.42 66.14,98.42 65.89,98.17 65.89,97.67 65.51,97.28 65.11,97.28 64.97,97.14 U78.2
CPSW_ETH1_D0P: length 10.1
  BOTTOM w0.089: J6.9 69.93,99.6 70.64,99.6 70.8,99.44 70.8,98.8 69.99,97.99 68.63,97.99 67.97,98.64 66.05,98.64 65.67,98.26 65.67,97.76 65.41,97.51 65.11,97.51 64.97,97.64 U78.1
CPSW_ETH1_D1M: length 10.2
  BOTTOM w0.089: U78.5 64.97,95.64 65.11,95.78 67.05,95.78 67.62,96.35 67.9,96.35 68.09,96.16 68.09,95.56 68.43,95.22 70.08,95.22 71.03,96.16 71.03,96.88 J6.8
CPSW_ETH1_D1P: length 10.2
  BOTTOM w0.089: U78.4 64.97,96.14 65.11,96.01 66.96,96.01 67.52,96.58 68,96.58 68.32,96.25 68.32,95.65 68.52,95.45 69.99,95.45 70.8,96.26 70.8,96.9 70.64,97.06 69.93,97.06 J6.7
CPSW_ETH1_D2M: length 10.2
  BOTTOM w0.089: J6.6 71.03,94.34 71.03,93.62 70.08,92.68 68.06,92.68 67.5,93.24 67.5,93.92 67.14,94.28 65.11,94.28 64.97,94.14 U78.8
CPSW_ETH1_D2P: length 10.2
  BOTTOM w0.089: U78.7 64.97,94.64 65.11,94.51 67.23,94.51 67.73,94.01 67.73,93.33 68.15,92.91 69.99,92.91 70.8,93.72 70.8,94.36 70.64,94.52 69.93,94.52 J6.5
CPSW_ETH1_D3M: length 10.2
  BOTTOM w0.089: U78.11 64.97,92.64 65.11,92.78 66.05,92.78 68.69,90.14 70.08,90.14 71.03,91.08 71.03,91.8 J6.4
CPSW_ETH1_D3P: length 10.2
  BOTTOM w0.089: J6.3 69.93,91.98 70.64,91.98 70.8,91.82 70.8,91.18 69.99,90.37 68.79,90.37 66.14,93.01 65.11,93.01 64.97,93.14 U78.10
CPSW_ETH1_GPIO_0: length 51.7
  TOP w0.14: TP20.1 58.07,100.86 v1(58.35,101.13) 58.35,101.27 58.26,101.36 R83.1
  L03_SIG01 w0.102: v1(81.1,80.73) 80.13,81.7 72.14,81.7 68.07,85.77 68.07,99.57 69.95,101.46 69.95,104 69.14,104.81 65.48,104.81 64.42,103.75 64.42,102.89 63.19,101.66 59.01,101.66 58.47,101.13 v1(58.35,101.13)
  BOTTOM w0.14: R83.1 58.26,101.22 v1(58.35,101.13) 58.51,100.97 R342.1 ; v1(81.1,80.73) 81.3,80.92 R365.1
CPSW_ETH1_GPIO_1: length 2.8
  TOP w0.14: R84.1 v1(59.53,101.11) 59.24,100.82 TP21.1
  BOTTOM w0.14: R341.1 59.4,100.98 v1(59.53,101.11) R84.1
CPSW_ETH1_LED0: length 4.7
  TOP w0.14: v1(64.98,101.89) TP18.1
  BOTTOM w0.14: v1(64.98,101.89) 64.98,101.39 63.81,100.23 63.81,99.94 63.15,99.28 U78.47
CPSW_ETH1_LED_1000: length 24.8
  TOP w0.14: TP23.1 v1(63.24,100.21) 63.4,100.37 R86.1
  L10_SIG03 w0.102: v1(80.8,106.13) 79.5,104.83 73.3,104.83 72.2,103.74 70.3,103.74 68.23,101.66 65.51,101.66 64.06,100.21 v1(63.24,100.21)
  BOTTOM w0.14: U78.46 62.65,99.67 63.18,100.2 63.23,100.2 v1(63.24,100.21) 63.24,100.27 63.4,100.43 R86.1 ; R327.1 v1(80.8,106.13)
CPSW_ETH1_LED_ACT: length 42.5
  TOP w0.14: TP22.1 62.06,99.95 v1(62.33,100.21) 62.13,100.41 R85.1
  L03_SIG01 w0.102: v1(78.3,81.22) 72.13,81.22 67.76,85.6 67.76,99.73 69.62,101.59 69.62,101.99 69.37,102.25 66.3,102.25 64.87,100.83 62.89,100.83 62.33,100.26 v1(62.33,100.21)
  BOTTOM w0.14: U78.45 62.15,100.03 v1(62.33,100.21) 62.13,100.41 R85.1 ; R364.1 v1(78.3,81.22)
CPSW_ETH2_D0N: length 10.2
  BOTTOM w0.089: J24.10 71.03,121.98 71.03,121.26 70.08,120.31 68.53,120.31 67.87,120.97 66.14,120.97 65.89,120.72 65.89,120.22 65.51,119.84 65.11,119.84 64.97,119.7 U125.2
CPSW_ETH2_D0P: length 10.1
  BOTTOM w0.089: J24.9 69.93,122.15 70.64,122.15 70.8,122 70.8,121.35 69.99,120.54 68.63,120.54 67.97,121.2 66.05,121.2 65.67,120.82 65.67,120.32 65.41,120.07 65.11,120.07 64.97,120.2 U125.1
CPSW_ETH2_D1M: length 10.2
  BOTTOM w0.089: J24.8 71.03,119.44 71.03,118.72 70.08,117.77 68.43,117.77 68.09,118.11 68.09,118.71 67.9,118.9 67.62,118.9 67.05,118.34 65.11,118.34 64.97,118.2 U125.5
CPSW_ETH2_D1P: length 10.2
  BOTTOM w0.089: J24.7 69.93,119.61 70.64,119.61 70.8,119.46 70.8,118.81 69.99,118 68.52,118 68.32,118.21 68.32,118.81 68,119.13 67.52,119.13 66.96,118.57 65.11,118.57 64.97,118.7 U125.4
CPSW_ETH2_D2M: length 10.2
  BOTTOM w0.089: J24.6 71.03,116.9 71.03,116.18 70.08,115.23 68.06,115.23 67.5,115.79 67.5,116.48 67.14,116.84 65.11,116.84 64.97,116.7 U125.8
CPSW_ETH2_D2P: length 10.2
  BOTTOM w0.089: J24.5 69.93,117.07 70.64,117.07 70.8,116.92 70.8,116.27 69.99,115.46 68.15,115.46 67.73,115.89 67.73,116.57 67.23,117.07 65.11,117.07 64.97,117.2 U125.7
CPSW_ETH2_D3M: length 10.2
  BOTTOM w0.089: U125.11 64.97,115.2 65.11,115.34 66.05,115.34 68.69,112.69 70.08,112.69 71.03,113.64 71.03,114.36 J24.4
CPSW_ETH2_D3P: length 10.2
  BOTTOM w0.089: J24.3 69.93,114.53 70.64,114.53 70.8,114.38 70.8,113.73 69.99,112.92 68.79,112.92 66.14,115.57 65.11,115.57 64.97,115.7 U125.10
CPSW_ETH2_GPIO_0: length 43.7
  TOP w0.14: R592.1 58.26,123.92 58.35,123.83 v1(58.35,123.69) 58.07,123.41 TP120.1
  L03_SIG01 w0.102: v1(71.72,104.4) 70.43,104.4 66.9,107.93 66.9,109.61 67.91,110.62 67.91,123.37 65.5,125.79 64.38,125.79 63.85,126.32 60.78,126.32 58.35,123.89 v1(58.35,123.69)
  BOTTOM w0.14: R588.1 77.49,103.49 76.88,104.09 72.03,104.09 v1(71.72,104.4) ; R586.1 58.51,123.52 v1(58.35,123.69) 58.26,123.78 R592.1
CPSW_ETH2_GPIO_1: length 2.8
  TOP w0.14: R601.1 v1(59.53,123.66) 59.24,123.38 TP118.1
  BOTTOM w0.14: R584.1 59.4,123.54 v1(59.53,123.66) R601.1
CPSW_ETH2_LED0: length 4.7
  TOP w0.14: v1(64.98,124.45) TP122.1
  BOTTOM w0.14: v1(64.98,124.45) 64.98,123.67 63.15,121.83 U125.47
CPSW_ETH2_LED_1000: length 31.6
  TOP w0.14: TP121.1 v1(63.24,122.77) 63.4,122.93 R603.1
  L03_SIG01 w0.102: v1(74.98,128.94) 72.81,126.78 68.55,126.78 67.76,125.99 66.39,125.99 66.21,126.17 65.38,126.17 64.89,126.65 60.29,126.65 57.75,124.11 57.75,123.35 58.59,122.51 60.39,122.51 60.57,122.33 62.8,122.33 v1(63.24,122.77)
  BOTTOM w0.14: U125.46 62.65,122.23 63.18,122.76 63.23,122.76 v1(63.24,122.77) 63.24,122.82 63.4,122.98 R603.1 ; R591.1 v1(74.98,128.94)
CPSW_ETH2_LED_ACT: length 20
  TOP w0.14: TP119.1 62.06,122.5 v1(62.33,122.77) 62.13,122.96 R596.1
  L05_SIG02 w0.102: v1(61.71,110.39) 61.71,111.51 62.53,112.32 63.39,112.32 63.75,112.68 63.75,120.96 62.33,122.38 v1(62.33,122.77)
  BOTTOM w0.14: R587.1 61.77,110.45 v1(61.71,110.39) ; R596.1 62.13,122.96 v1(62.33,122.77) 62.15,122.59 U125.45
CPSW_ETH_INTN: length 52.5
  TOP w0.14: v1(63.02,103.44) 62.4,103.44 R78.1 ; v1(34.19,124.41) 34.19,122.13 33.37,121.32 33.37,118.51 33.96,117.92 R53.1
  L03_SIG01 w0.102: v1(55.53,109.69) 57.41,109.69 58.52,108.57 58.52,105.58 58.88,105.22 58.88,103.01 59.9,101.99 61.7,101.99 62.08,102.37 62.08,102.79 62.73,103.44 v1(63.02,103.44)
  L10_SIG03 w0.102: v1(34.19,124.41) 40.5,124.41 41.28,123.64 43.34,123.64 43.56,123.42 45.03,123.42 45.8,122.65 45.8,122.28 46.33,121.76 46.89,121.76 54.02,114.63 54.02,111.2 v1(55.53,109.69)
CPSW_RGMII1_ETH1_CLK: length 58.5
  TOP w0.14: v1(54.92,134.18) 54.92,134.94 55.76,135.78 R26.2
  L05_SIG02 w0.102: v1(63.15,90.29) 63.15,91.68 62.77,92.06 62.77,102.02 62.94,102.2 62.94,102.78 63.48,103.32 63.48,105.24 62.77,105.96 62.77,107.89 64.56,109.68 64.56,115.32 64.08,115.8 64.08,122.59 62.59,124.08 61.51,124.08 60.83,124.77 60.11,124.77 58.53,126.35 55.04,126.35 53.83,127.57 53.83,131.41 54.92,132.51 v1(54.92,134.18)
  BOTTOM w0.14: v1(63.15,90.29) 62.65,90.8 U78.15
CPSW_RGMII1_ETH1_CLK_OUT: length 5.1
  TOP w0.132: TP28.1 58.75,88.74 v1(59.01,88.99)
  BOTTOM w0.14: v1(59.01,88.99) 59.34,88.65 60.14,88.65 61.03,89.54 61.03,90.41 61.15,90.53 U78.18
CPSW_RGMII1_ETH1_RBIAS: length 2.6
  BOTTOM w0.14: U78.12 64.65,92.14 65.01,91.78 65.01,91.66 R351.1 65.44,90.66 65.57,90.53 C307.2
CPSW_RGMII1_MDC: length 2.5
  TOP w0.14: R108.2 v1(62.28,90.29)
  BOTTOM w0.14: U78.16 62.15,90.42 v1(62.28,90.29) R354.1
CPSW_RGMII1_MDIO: length 2.4
  TOP w0.14: R107.2 v1(61.52,90.29)
  BOTTOM w0.14: U78.17 61.65,90.42 v1(61.52,90.29) R355.2
CPSW_RGMII1_RD0: length 32.3
  TOP w0.132: U18.AB16 v1(48.28,107.66)
  TOP w0.14: R96.2 56.38,96.51 v1(56.16,96.73)
  L05_SIG02 w0.102: v1(56.16,96.73) 56.59,96.73 56.75,96.89 56.75,97.05 56.38,97.42 56.38,97.59 56.49,97.7 56.64,97.7 57.02,97.32 57.18,97.32 57.29,97.43 57.29,97.59 56.87,98.01 56.87,98.15 56.98,98.27 57.15,98.27 57.56,97.85 57.72,97.85 57.83,97.97 57.83,98.12 57.58,98.38 57.58,98.52 57.69,98.63 57.86,98.63 58.1,98.39 58.26,98.39 58.43,98.56 58.43,100.63 58.33,100.73 58.13,100.73 58.03,100.63 58.03,99.57 57.92,99.47 57.74,99.47 57.64,99.56 57.64,101.1 58.42,101.87 58.42,104.22 55.22,107.41 54.04,107.41 53.89,107.27 53.66,107.27 53.51,107.41 52.58,107.41 52.47,107.3 52.47,107.09 52.36,106.98 52.2,106.98 52.09,107.09 52.09,107.3 51.98,107.41 51.72,107.41 51.47,107.66 50.96,107.66 50.79,107.5 50.58,107.5 50.41,107.66 49.23,107.66 49.1,107.54 49.1,107.29 48.99,107.18 48.39,107.18 48.28,107.28 48.28,107.66 v1(48.28,107.66)
  BOTTOM w0.14: U78.33 57.37,96.17 56.62,96.17 56.16,96.63 v1(56.16,96.73) 55.61,96.73 R347.1
CPSW_RGMII1_RD1: length 30.9
  TOP w0.132: U18.V15 v1(45.08,106.86)
  L05_SIG02 w0.102: v1(45.08,106.86) 44.88,106.86 44.48,106.46 44.06,106.46 43.88,106.29 43.88,105.1 44.11,104.86 48.73,104.86 49.25,104.34 51.59,104.34 51.76,104.5 52.29,104.5 54.54,102.25 54.72,102.25 54.86,102.38 54.86,102.57 52.71,104.72 52.71,104.86 52.88,105.03 53.04,105.03 55.23,102.84 55.23,101.37 54.36,100.5 54.36,98.58 v1(55.54,97.41)
  BOTTOM w0.14: v1(55.54,97.41) 56.07,97.41 56.83,96.64 U78.34
CPSW_RGMII1_RD2: length 32.3
  TOP w0.132: U18.W15 v1(45.88,106.86)
  TOP w0.14: v1(56.2,98) 56.43,97.78 R93.2
  L05_SIG02 w0.102: v1(45.88,106.86) 45.65,106.86 45.25,106.47 44.84,106.47 44.68,106.31 44.68,105.82 44.84,105.66 48.36,105.66 49.38,104.64 50.42,104.64 50.56,104.78 50.93,104.78 51.07,104.64 51.27,104.64 51.45,104.81 51.45,105.33 51.63,105.51 53.12,105.51 53.36,105.26 53.7,105.26 53.9,105.46 54.31,105.46 55.78,104 55.78,103.78 55.68,103.68 55.52,103.68 54.19,105.01 54.02,105.01 53.9,104.89 53.9,104.72 55.37,103.25 55.57,103.25 55.8,103.02 55.8,100.49 55.62,100.31 54.87,100.31 54.71,100.15 54.71,99.89 54.83,99.77 55.17,99.77 55.31,99.63 55.31,99.33 55.19,99.21 54.81,99.21 54.71,99.11 54.71,98.81 54.83,98.69 55.2,98.69 55.31,98.57 55.31,98.19 55.5,98 v1(56.2,98)
  BOTTOM w0.14: R346.1 56.05,98.16 v1(56.2,98) 56.37,97.84 56.37,97.68 56.9,97.14 U78.35
CPSW_RGMII1_RD3: length 30.9
  TOP w0.132: U18.V14 v1(45.08,106.06)
  L05_SIG02 w0.102: v1(45.08,106.06) 45.3,106.06 45.7,106.47 47.07,106.47 47.18,106.35 47.18,106.15 47.28,106.05 47.63,106.05 47.72,106.14 47.72,106.34 47.82,106.44 48.07,106.44 48.17,106.34 48.17,106.15 48.27,106.05 48.75,106.05 49.13,106.42 49.59,106.42 49.76,106.25 49.76,105.8 49.93,105.63 50.67,105.63 50.87,105.83 54.64,105.83 56.12,104.36 56.12,101.87 56.23,101.76 56.43,101.76 56.54,101.86 56.54,102.26 56.64,102.36 57.09,102.36 57.19,102.46 57.19,102.72 57.09,102.82 56.61,102.82 56.51,102.92 56.51,103.98 56.63,104.1 56.82,104.1 56.93,103.99 56.93,103.81 57.02,103.72 57.24,103.72 57.34,103.82 57.34,104 57.44,104.1 57.66,104.1 57.79,103.97 57.79,102.44 56.21,100.86 56.21,100.11 55.63,99.53 55.63,98.85 55.84,98.64 v1(56.8,98.64)
  BOTTOM w0.14: v1(56.8,98.64) 56.8,97.96 57.11,97.64 U78.36
CPSW_RGMII1_RESETN: length 83.8
  TOP w0.14: v1(63.78,41.67) 64,41.89 U41.4
  L05_SIG02 w0.102: v1(63.78,41.67) 63.78,41.19 64,40.97 64,39.37 64.75,38.62 64.75,37.99 63.65,36.89 61.33,36.89 58.63,39.59 56.93,39.59 55.45,41.07 55.45,44.72 55.27,44.9 55.27,46.78 57.81,49.32 57.81,53.79 57.53,54.06 57.53,66.02 59.79,68.28 59.79,73.31 63.73,77.25 63.73,79.87 62.95,80.65 62.94,84.54 62.85,84.63 62.85,87.73 60.86,89.73 60.86,91.78 61.34,92.27 61.34,97.85 61.45,97.96 61.45,99.74 v1(60.88,100.31)
  BOTTOM w0.14: R440.1 64.01,41.9 v1(63.78,41.67) ; U78.43 61.15,98.93 61.22,99 61.22,99.97 v1(60.88,100.31)
CPSW_RGMII1_RX_CTL: length 31
  TOP w0.132: U18.AA15 v1(47.48,106.86)
  L05_SIG02 w0.102: v1(56.05,99.17) 56.43,99.17 56.56,99.3 56.56,100.24 56.66,100.34 56.84,100.34 56.94,100.24 56.94,99.26 57.06,99.14 57.21,99.14 57.31,99.24 57.31,101.3 58.09,102.08 58.09,104.1 57.5,104.69 57.28,104.69 57.1,104.51 56.75,104.51 56.57,104.69 56.33,104.69 55.03,105.99 55.03,106.14 55.18,106.28 55.34,106.28 56.33,105.28 56.53,105.28 56.63,105.39 56.63,105.57 55.57,106.64 52.6,106.64 52.49,106.53 52.49,106.32 52.38,106.2 52.22,106.2 52.11,106.32 52.11,106.53 52,106.64 51.84,106.64 51.73,106.53 51.73,106.32 51.62,106.2 51.46,106.2 51.35,106.32 51.35,106.53 51.24,106.64 50.76,106.64 50.1,107.3 49.73,107.3 49.29,106.86 v1(47.48,106.86)
  BOTTOM w0.14: v1(56.05,99.17) R340.2 R339.2 57.91,99.77 58.65,99.03 U78.38
CPSW_RGMII1_RXC: length 29.2
  TOP w0.132: U18.AA16 v1(47.48,107.66)
  L05_SIG02 w0.102: v1(47.48,107.66) 47.88,108.06 51.63,108.06 51.89,107.81 55.28,107.81 58.75,104.34 58.75,98.39 56.67,96.32 55.96,96.32 54.38,97.89 54.09,97.89 v1(53.82,98.16)
  BOTTOM w0.14: v1(53.82,98.16) 53.63,97.97 53.63,96.48 54.56,95.55 R348.1
CPSW_RGMII1_TD0: length 27.3
  TOP w0.132: U18.Y17 v1(46.68,108.46)
  L03_SIG01 w0.102: v1(56.4,93.49) 56.95,94.04 56.95,97.88 56.38,98.45 56.38,98.85 56.66,99.12 56.66,100.07 56.32,100.41 56.32,101.74 56.44,101.86 56.73,101.86 56.85,101.97 56.85,102.14 56.73,102.26 56.44,102.26 56.32,102.38 56.32,102.85 56.09,103.09 56.09,104.85 55.74,105.19 55.74,105.36 55.87,105.5 55.87,105.67 55.76,105.78 55.59,105.78 55.45,105.65 55.28,105.65 55.17,105.77 55.17,105.94 55.3,106.07 55.3,106.24 55.18,106.36 55.01,106.36 54.88,106.23 54.71,106.23 53.49,107.45 51.99,107.45 50.58,108.85 49.36,108.85 48.57,108.07 47.08,108.07 v1(46.68,108.46)
  BOTTOM w0.14: v1(56.4,93.49) 56.73,93.49 56.88,93.64 U78.28
CPSW_RGMII1_TD1: length 27.3
  TOP w0.132: U18.V16 v1(45.08,107.66)
  L03_SIG01 w0.102: v1(55.5,92.06) 54.9,92.67 54.9,93.97 55.34,94.42 55.34,96.55 54.71,97.18 54.71,103.18 52.99,104.89 52.69,104.89 51.67,105.92 51.51,105.92 50.78,106.65 50.4,106.65 50.13,106.39 49.56,106.39 49.07,106.88 48.31,106.88 47.9,106.47 46.44,106.47 46.28,106.62 46.28,107.03 46.05,107.26 45.48,107.26 v1(45.08,107.66)
  BOTTOM w0.14: U78.27 56.92,93.14 56.85,93.07 55.97,93.07 55.5,92.59 v1(55.5,92.06)
CPSW_RGMII1_TD2: length 27.3
  TOP w0.132: U18.Y16 v1(46.68,107.66)
  L03_SIG01 w0.102: v1(46.68,107.66) 47.08,107.26 48.68,107.26 49.02,107.6 50.6,107.6 50.77,107.43 50.77,107.09 51.2,106.66 52.18,106.66 52.36,106.48 52.36,105.91 52.97,105.29 53.63,105.29 53.89,105.04 54.05,105.04 54.32,105.3 54.49,105.3 54.61,105.18 54.61,105.01 54.34,104.75 54.34,104.58 54.46,104.46 54.63,104.46 54.9,104.73 55.06,104.73 55.18,104.61 55.18,104.44 54.92,104.17 54.92,104 55.28,103.64 55.28,102.58 55.43,102.43 55.43,101.5 55.02,101.09 55.02,97.33 55.72,96.63 55.72,94.35 55.23,93.86 55.23,92.96 55.61,92.58 v1(56.4,92.58)
  BOTTOM w0.14: v1(56.4,92.58) 56.46,92.64 U78.26
CPSW_RGMII1_TD3: length 27.3
  TOP w0.132: U18.AA17 v1(47.48,108.46)
  L03_SIG01 w0.102: v1(56.44,91.63) 57.25,92.44 57.25,102.57 56.52,103.3 56.52,105.61 54.65,107.47 54.08,107.47 53.76,107.8 52.06,107.8 50.71,109.16 49.13,109.16 48.83,108.86 48.11,108.86 47.71,108.46 v1(47.48,108.46)
  BOTTOM w0.14: v1(56.44,91.63) 56.44,91.92 56.66,92.14 U78.25
CPSW_RGMII1_TX_CTL: length 27.3
  TOP w0.132: U18.W16 v1(45.88,107.66)
  L03_SIG01 w0.102: v1(57.66,99.05) 57.66,103.92 57.54,104.03 57.11,104.03 56.99,104.15 56.99,104.32 57.11,104.44 57.54,104.44 57.66,104.56 57.66,105.04 57.02,105.67 57.02,105.84 57.38,106.2 57.38,106.37 57.26,106.49 57.09,106.49 56.74,106.13 56.57,106.13 56.08,106.62 56.08,106.79 56.41,107.12 56.41,107.29 56.29,107.41 56.12,107.41 55.79,107.08 55.62,107.08 55.5,107.19 55.5,107.36 55.84,107.69 55.84,107.86 55.72,107.98 55.55,107.98 55.22,107.65 55.05,107.65 54.9,107.79 54.26,107.79 53.85,108.21 52.82,108.21 52.23,108.8 51.62,108.8 50.93,109.49 48.65,109.49 48.45,109.69 48.08,109.69 47.88,109.49 47.88,109.1 47.65,108.86 46.47,108.86 46.28,108.68 46.28,108.07 v1(45.88,107.66)
  BOTTOM w0.14: U78.37 58.15,98.91 58.01,99.05 v1(57.66,99.05)
CPSW_RGMII1_TXC: length 24.2
  L03_SIG01 w0.102: v1(55.64,93.49) 56.03,93.89 56.03,95.39 56.56,95.92 56.56,97.03 55.41,98.17 55.41,99.98 55.53,100.1 55.76,100.1 55.86,100.2 55.86,102.68 55.66,102.89 55.66,104.77 54.66,105.78 53.04,105.78 52.69,106.13 52.69,106.83 52.48,107.04 51.91,107.04 50.81,108.14 50.44,108.14 50.21,107.91 49.53,107.91 49.4,108.04 49.4,108.34 49.53,108.46 v1(49.93,108.46)
  BOTTOM w0.14: R322.2 v1(49.93,108.46) ; v1(55.64,93.49) 56.11,93.97 56.65,93.97 56.82,94.14 U78.29
CPSW_RGMII2_ETH2_CLK: length 29.9
  TOP w0.14: v1(54.48,133.13) R37.2
  L05_SIG02 w0.102: v1(63.15,112.85) 62.5,113.5 62.5,114.69 62.76,114.94 62.76,120.81 61.28,122.28 61.28,123.47 60.57,124.19 59.91,124.19 58.41,125.68 54.98,125.68 53.57,127.1 53.57,132.22 v1(54.48,133.13)
  BOTTOM w0.14: U125.15 62.65,113.36 v1(63.15,112.85)
CPSW_RGMII2_ETH2_CLK_OUT: length 5.1
  TOP w0.132: TP126.1 58.99,111.29 v1(59.28,111)
  BOTTOM w0.14: v1(59.28,111) 59.48,111.21 60.14,111.21 61.03,112.09 61.03,112.97 61.15,113.09 U125.18
CPSW_RGMII2_ETH2_RBIAS: length 2.6
  BOTTOM w0.14: C556.2 65.57,113.08 65.44,113.22 R611.1 65.01,114.22 65.01,114.34 64.65,114.7 U125.12
CPSW_RGMII2_MDC: length 2.5
  TOP w0.14: R606.2 v1(62.28,112.85)
  BOTTOM w0.14: R609.2 v1(62.28,112.85) 62.15,112.98 U125.16
CPSW_RGMII2_MDIO: length 2.4
  TOP w0.14: R608.2 v1(61.52,112.85)
  BOTTOM w0.14: U125.17 61.65,112.98 v1(61.52,112.85) R607.1
CPSW_RGMII2_RD0: length 30
  TOP w0.132: U18.AA21 v1(47.48,111.66)
  TOP w0.14: v1(56.16,119.28) 56.38,119.06 R599.2
  L03_SIG01 w0.102: v1(47.48,111.66) 47.88,111.26 50.59,111.26 52.99,113.66 52.99,116.73 52.58,117.14 52.06,117.14 51.96,117.24 51.96,117.51 52.09,117.63 52.09,117.78 51.98,117.89 51.38,117.89 51.28,117.99 51.28,118.14 51.38,118.24 51.98,118.24 52.09,118.35 52.09,118.59 51.98,118.7 51.84,118.7 51.73,118.8 51.73,118.95 51.84,119.05 51.98,119.05 52.09,119.16 52.09,119.33 53.31,120.55 53.31,121.95 53.49,122.13 54.02,122.13 54.2,121.95 54.2,121.74 54.09,121.63 53.82,121.63 53.71,121.53 53.71,121.38 53.82,121.28 54.09,121.28 54.2,121.17 54.2,121.02 54.09,120.92 53.82,120.92 53.71,120.82 53.71,120.67 53.82,120.56 54.09,120.56 54.2,120.46 54.2,120.31 54.09,120.21 53.82,120.21 53.71,120.1 53.71,119.96 53.82,119.85 54.09,119.85 54.2,119.75 54.2,119.28 54.76,118.72 55.8,118.72 56.16,119.09 v1(56.16,119.28)
  BOTTOM w0.14: R597.1 55.61,119.28 v1(56.16,119.28) 56.16,119.18 56.62,118.73 57.37,118.73 U125.33
CPSW_RGMII2_RD1: length 28.6
  TOP w0.132: U18.Y20 v1(46.68,110.86)
  L03_SIG01 w0.102: v1(46.68,110.86) 47.08,111.26 47.08,111.88 47.27,112.07 50.15,112.07 51.87,113.78 51.87,115.46 50.18,117.15 50.18,117.96 50.08,118.07 49.45,118.07 49.35,118.17 49.35,118.32 49.45,118.42 50.08,118.42 50.18,118.53 50.18,118.67 50.08,118.78 49.45,118.78 49.35,118.88 49.35,119.03 49.45,119.13 50.08,119.13 50.18,119.24 50.18,119.44 51.53,120.78 52.18,120.78 52.64,121.24 52.64,122.52 53.05,122.94 54.37,122.94 54.83,122.48 54.83,120.67 v1(55.54,119.96)
  BOTTOM w0.14: v1(55.54,119.96) 56.07,119.96 56.83,119.2 U125.34
CPSW_RGMII2_RD2: length 30.3
  TOP w0.132: U18.AB21 v1(48.28,111.66)
  TOP w0.14: v1(56.2,120.56) 56.43,120.33 R595.2
  L03_SIG01 w0.102: v1(48.28,111.66) 50.41,111.66 52.63,113.88 52.63,114.18 52.51,114.3 52.37,114.3 52.25,114.42 52.25,114.59 52.37,114.7 52.51,114.7 52.63,114.82 52.63,114.99 52.51,115.11 52.37,115.11 52.25,115.23 52.25,115.4 52.37,115.52 52.51,115.52 52.63,115.64 52.63,115.8 52.51,115.92 52.37,115.92 52.25,116.04 52.25,116.21 52.37,116.33 52.51,116.33 52.63,116.45 52.63,116.62 52.51,116.74 51.94,116.74 51.83,116.63 51.83,116.31 51.73,116.21 51.58,116.21 51.48,116.31 51.48,116.63 51.37,116.74 51.18,116.74 50.51,117.4 50.51,117.8 50.62,117.91 50.84,117.91 50.95,118.01 50.95,118.16 50.84,118.26 50.62,118.26 50.51,118.37 50.51,119.31 51.61,120.4 52.27,120.4 52.98,121.11 52.98,122.38 53.21,122.61 54.27,122.61 54.53,122.36 54.53,119.91 54.98,119.46 55.64,119.46 56.25,120.07 56.25,120.51 v1(56.2,120.56)
  BOTTOM w0.14: U125.35 56.9,119.7 56.37,120.23 56.37,120.39 v1(56.2,120.56) 56.05,120.71 R600.1
CPSW_RGMII2_RD3: length 28.6
  TOP w0.132: U18.AB20 48.28,110.86 v1(48.97,110.86)
  L03_SIG01 w0.102: v1(48.97,110.86) 50.81,110.86 53.76,113.82 53.76,114.46 53.65,114.58 53.41,114.58 53.29,114.7 53.29,114.87 53.41,114.99 53.65,114.99 53.76,115.1 53.76,115.27 53.65,115.39 53.41,115.39 53.29,115.51 53.29,115.68 53.41,115.8 53.65,115.8 53.76,115.92 53.76,116.09 53.65,116.2 53.41,116.2 53.29,116.32 53.29,116.91 52.55,117.66 52.55,117.77 52.65,117.87 53.08,117.87 53.18,117.98 53.18,118.12 53.08,118.23 52.65,118.23 52.55,118.33 52.55,118.48 52.65,118.58 53.08,118.58 53.18,118.69 53.18,118.83 53.08,118.94 52.65,118.94 52.55,119.04 52.55,119.18 52.88,119.51 53.69,119.51 53.89,119.31 53.89,119.16 54.63,118.42 55.92,118.42 56.84,119.33 56.84,120.81 56.63,121.01 55.9,121.01 55.7,121.21 55.7,121.93 55.82,122.05 56.23,122.05 56.33,121.95 v1(56.33,121.49)
  BOTTOM w0.14: U125.36 57.11,120.2 56.8,120.52 56.8,121.03 v1(56.33,121.49)
CPSW_RGMII2_RSTN: length 104.5
  TOP w0.14: R314.1 61.14,123.12 v1(60.88,122.86) ; v1(62.25,37.55) 63.09,38.38 64.15,38.38 64.33,38.56 U42.4
  L05_SIG02 w0.102: v1(60.88,122.86) 60.09,122.86 59.15,121.93 59.15,113.75 61.31,111.59 61.31,110.93 61.14,110.76 61.14,107.56 61.32,107.38 61.32,103.93 61.93,103.32 61.93,102.4 61.37,101.84 61.37,100.27 61.7,99.94 61.7,97.73 61.57,97.6 61.57,92.17 61.09,91.69 61.09,89.9 63.81,87.19 63.81,80.17 63.96,80.02 63.96,77.13 60.12,73.3 60.12,67.12 59.79,66.79 59.79,50.89 55.53,46.62 55.53,45.48 56.42,44.59 56.42,41.54 57.36,40.6 58.46,40.6 59.53,39.53 60.9,39.53 61.1,39.73 61.97,39.73 62.25,39.45 v1(62.25,37.55)
  BOTTOM w0.14: U125.43 61.15,121.48 61.22,121.55 61.22,122.53 v1(60.88,122.86)
CPSW_RGMII2_RX_CTL: length 28.9
  TOP w0.132: U18.W18 v1(45.88,109.26)
  L03_SIG01 w0.102: v1(45.88,109.26) 46.08,109.46 46.08,109.69 46.28,109.89 46.28,110.23 46.51,110.46 48.38,110.46 48.66,110.18 51.21,110.18 53.41,112.38 53.58,112.38 53.79,112.16 53.96,112.16 54.08,112.28 54.08,112.45 53.86,112.66 53.86,112.83 53.98,112.95 54.15,112.95 54.37,112.74 54.53,112.74 54.65,112.86 54.65,113.02 54.44,113.24 54.44,113.41 55.06,114.03 55.06,115.12 55.2,115.25 55.2,116.25 56.05,117.1 56.05,118.04 57.22,119.21 57.22,121.52 56.36,122.38 55.42,122.38 v1(55.31,122.28)
  BOTTOM w0.14: v1(55.31,122.28) 55.36,122.32 R602.2 R593.2 57.91,122.32 58.65,121.58 U125.38
CPSW_RGMII2_RXC: length 26.7
  TOP w0.132: U18.AA20 v1(47.48,110.86)
  L03_SIG01 w0.102: v1(47.48,110.86) 48.38,110.86 48.76,110.48 51.01,110.48 54.1,113.57 54.1,114.07 54.2,114.17 54.57,114.17 54.68,114.27 54.68,114.42 54.57,114.53 54.2,114.53 54.1,114.63 54.1,114.78 54.2,114.88 54.57,114.88 54.68,114.99 54.68,115.13 54.57,115.24 54.2,115.24 54.1,115.34 54.1,115.49 54.23,115.62 54.72,115.62 54.83,115.72 54.83,115.86 54.71,115.97 54.2,115.97 54.1,116.08 54.1,116.61 53.49,117.23 53.49,118.59 53.59,118.69 53.87,118.69 54.13,118.43 54.13,117.38 54.24,117.28 54.38,117.28 54.49,117.39 54.49,118.01 54.59,118.12 54.75,118.12 54.86,118.01 54.86,117.86 54.96,117.76 55.11,117.76 55.46,118.12 55.64,118.12 55.7,118.06 55.7,117.2 54.96,116.46 v1(54.63,116.46)
  BOTTOM w0.14: v1(54.63,116.46) 54.35,116.74 54.35,118.27 54.6,118.52 54.81,118.52 54.98,118.35 R582.1
CPSW_RGMII2_TD0: length 19.6
  TOP w0.132: U18.AA19 v1(47.48,110.06)
  L05_SIG02 w0.102: v1(47.48,110.06) 47.87,110.45 49.51,110.45 52.05,113 52.05,114.96 52.21,115.11 52.35,115.11 52.71,114.75 52.86,114.75 52.97,114.85 52.97,115 52.61,115.36 52.61,115.51 52.71,115.61 52.86,115.61 53.22,115.25 53.37,115.25 53.47,115.36 53.47,115.5 53.11,115.86 53.11,116.01 53.21,116.12 53.36,116.12 53.72,115.75 53.87,115.75 53.97,115.86 53.97,116.01 53.61,116.37 53.61,116.51 53.99,116.9 54.96,116.9 55.11,116.74 55.11,115.68 55.34,115.45 55.8,115.45 v1(56.4,116.05)
  BOTTOM w0.14: U125.28 56.88,116.2 56.73,116.05 v1(56.4,116.05)
CPSW_RGMII2_TD1: length 19.4
  TOP w0.132: U18.Y18 v1(46.68,109.26)
  L05_SIG02 w0.102: v1(46.68,109.26) 46.68,109.27 47.08,109.67 47.31,109.67 47.69,109.67 48.13,110.1 49.82,110.1 50.05,110.34 50.2,110.34 50.35,110.19 50.49,110.19 50.6,110.3 50.6,110.45 50.45,110.59 50.45,110.74 50.56,110.84 50.7,110.84 50.85,110.7 51,110.7 51.1,110.8 51.1,110.95 50.95,111.09 50.95,111.24 52.9,113.19 52.9,113.34 52.5,113.74 52.5,113.88 52.61,113.99 52.76,113.99 53.16,113.59 53.3,113.59 53.41,113.69 53.41,113.84 53.01,114.24 53.01,114.39 53.11,114.49 53.26,114.49 53.66,114.09 53.81,114.09 53.91,114.2 53.91,114.34 53.51,114.74 53.51,114.89 53.61,114.99 53.76,114.99 54.16,114.59 54.31,114.59 54.38,114.67 55.45,114.67 v1(55.5,114.62)
  BOTTOM w0.14: U125.27 56.92,115.7 56.85,115.62 55.97,115.62 55.5,115.15 v1(55.5,114.62)
CPSW_RGMII2_TD2: length 19.4
  TOP w0.132: U18.AA18 v1(47.48,109.26)
  L05_SIG02 w0.102: v1(56.4,115.13) 56.08,114.81 56.08,114.58 55.58,114.09 54.43,114.09 54.19,113.86 54.19,113.69 54.46,113.43 54.46,113.26 54.34,113.14 54.17,113.14 53.91,113.4 53.74,113.4 52.42,112.08 52.42,111.77 52.31,111.67 52.04,111.67 51.94,111.56 51.94,111.42 52.04,111.31 52.31,111.31 52.42,111.21 52.42,110.77 53.16,110.04 53.16,109.83 52.89,109.57 52.71,109.57 52.11,110.16 51.76,110.16 51.33,109.74 50,109.74 49.89,109.64 49.89,109.27 49.79,109.17 49.64,109.17 49.54,109.27 49.54,109.64 49.43,109.74 49.29,109.74 49.18,109.64 49.18,109.27 49.08,109.17 48.93,109.17 48.83,109.27 48.83,109.64 48.72,109.74 48.14,109.74 47.66,109.26 v1(47.48,109.26)
  BOTTOM w0.14: v1(56.4,115.13) 56.46,115.2 U125.26
CPSW_RGMII2_TD3: length 19.3
  TOP w0.132: U18.W17 v1(45.88,108.46)
  L05_SIG02 w0.102: v1(45.88,108.46) 46.28,108.86 50.56,108.86 50.66,108.97 50.66,109.2 50.77,109.3 50.91,109.3 51.02,109.2 51.02,108.97 51.12,108.86 51.27,108.86 51.37,108.97 51.37,109.2 51.48,109.3 51.62,109.3 51.73,109.2 51.73,108.97 51.83,108.86 52.67,108.86 54.07,110.27 54.07,110.9 53.76,111.21 52.98,111.21 52.77,111.41 52.77,111.76 53.68,112.67 54.69,112.67 56.21,114.18 v1(56.44,114.18)
  BOTTOM w0.14: v1(56.44,114.18) 56.44,114.47 56.66,114.7 U125.25
CPSW_RGMII2_TX_CTL: length 19.8
  TOP w0.132: U18.Y19 v1(46.68,110.06)
  L05_SIG02 w0.102: v1(57.66,121.6) 57.66,119.98 55.92,118.24 54.91,118.24 51.66,114.99 51.66,113.15 49.77,111.26 47.28,111.26 47.08,111.06 47.08,110.43 46.71,110.06 v1(46.68,110.06)
  BOTTOM w0.14: v1(57.66,121.6) 58.01,121.6 58.15,121.47 U125.37
CPSW_RGMII2_TXC: length 14.4
  TOP w0.14: R56.2 v1(53.31,111.6)
  L05_SIG02 w0.102: v1(53.31,111.6) 54.57,111.6 54.74,111.77 54.89,111.77 55.14,111.51 55.29,111.51 55.4,111.62 55.4,111.77 55.14,112.02 55.14,112.17 55.24,112.28 55.39,112.28 55.65,112.02 55.79,112.02 55.9,112.12 55.9,112.27 55.64,112.53 55.64,112.68 55.74,112.78 55.89,112.78 56.15,112.52 56.3,112.52 56.4,112.62 56.4,112.77 56.14,113.03 56.14,113.18 57.09,114.13 57.09,116.16 56.74,116.51 56.1,116.51 v1(55.64,116.05)
  BOTTOM w0.14: U125.29 56.82,116.7 56.65,116.52 56.11,116.52 v1(55.64,116.05)
CPSW_RGMII2_TXC_R: length 5
  TOP w0.14: U18.AB19 48.3,110.08 49.83,110.08 50.79,111.04 R56.1
CPSW_RGMII_INTN: length 43.4
  TOP w0.14: R78.2 61.52,103.12 v1(61.52,102.63)
  L03_SIG01 w0.102: v1(61.52,102.63) 62.15,103.26 62.15,108.28 62.77,108.89 65.73,108.89 67.62,110.79 67.62,123.02 65.72,124.92 63.87,124.92 63.53,124.58 62.11,124.58 61.52,125.17 v1(61.52,125.19)
  BOTTOM w0.14: v1(61.52,102.63) 61.46,102.63 61.32,102.49 61.32,101.92 61.13,101.73 R335.1 61.24,101.16 61.24,100.68 61.67,100.25 61.67,98.42 U78.44 ; v1(61.52,125.19) 61.56,125.15 61.56,124.59 61.25,124.28 R610.2 60.67,124.01 61.24,123.44 61.24,123.19 61.67,122.76 61.67,120.97 U125.44
CPSW_RGMII_TXC_R: length 1.1
  TOP w0.132: U18.AB17 v1(48.28,108.46)
  BOTTOM w0.14: R322.1 v1(48.28,108.46)
CS_LM5141: length 12.9
  L03_SIG01 w0.254: v1(35.44,55.39) 35.44,47.96 36.35,47.04 36.35,44.61 v1(36.95,44.01)
  BOTTOM w0.254: U89.18 36.6,44.36 v1(36.95,44.01)
CSI0_FLEX_RXCLKN: length 20.1
  TOP w0.089: U8.28 70.33,136.04 70.19,136.18 70.19,137.64 69.89,137.94 69.89,138.89 69.99,138.99 70.23,138.99 v1(70.47,138.75)
  BOTTOM w0.089: J20.8 69.58,148.61 69.71,148.47 69.71,146.29 71.36,144.64 71.36,143.75 71.09,143.48 70.08,143.48 69.65,143.06 69.65,142.42 70.08,141.99 71.18,141.99 71.41,141.77 71.41,141.15 71.19,140.94 69.96,140.94 69.57,140.55 69.57,139.29 69.86,138.99 70.23,138.99 v1(70.47,138.75)
CSI0_FLEX_RXCLKP: length 20.1
  TOP w0.089: U8.29 69.83,136.04 69.96,136.18 69.96,137.54 69.66,137.84 69.66,138.99 69.9,139.22 70.23,139.22 v1(70.47,139.46)
  BOTTOM w0.089: J20.9 70.08,148.63 69.94,148.49 69.94,146.39 71.59,144.74 71.59,143.65 71.19,143.25 70.17,143.25 69.88,142.96 69.88,142.51 70.17,142.22 71.27,142.22 71.64,141.86 71.64,141.06 71.29,140.71 70.05,140.71 69.79,140.45 69.79,139.38 69.96,139.22 70.22,139.22 v1(70.47,139.46)
CSI0_FLEX_RXN0: length 20.1
  TOP w0.089: v1(71.46,136.68) 71.19,136.42 71.19,136.18 71.33,136.04 U8.26
  BOTTOM w0.089: J20.2 66.58,148.59 66.71,148.45 66.71,145.38 66.53,145.21 66.15,145.21 65.78,144.84 65.78,140.46 66.15,140.09 66.53,140.09 66.71,139.91 66.71,137.74 68.69,135.77 70.94,135.77 71.29,136.12 71.29,136.51 v1(71.46,136.68)
CSI0_FLEX_RXN1: length 20.1
  TOP w0.089: U8.24 72.33,136.04 72.19,136.18 72.19,137.35 72.6,137.76 72.6,138.52 v1(72.83,138.75)
  BOTTOM w0.089: J20.5 68.08,148.63 68.21,148.5 68.21,146.01 68.6,145.62 68.6,144 68.21,143.61 68.21,142.85 68.62,142.44 68.62,141.2 68.21,140.8 68.21,138.64 68.85,138 72.41,138 72.67,138.27 72.67,138.59 v1(72.83,138.75)
CSI0_FLEX_RXN2: length 20.1
  TOP w0.089: v1(74.46,137.21) 74.2,137.46 73.47,137.46 73.19,137.18 73.19,136.18 73.33,136.04 U8.22
  BOTTOM w0.089: v1(74.46,137.21) 74.23,137.43 73.9,137.43 73.64,137.69 73.64,139.02 73.99,139.36 74.61,139.36 74.82,139.57 74.82,139.87 74.61,140.09 73.99,140.09 73.64,140.43 73.64,140.92 73.99,141.27 74.61,141.27 74.82,141.48 74.82,141.78 74.61,141.99 73.99,141.99 73.64,142.34 73.64,144.36 71.21,146.8 71.21,148.42 71.08,148.56 J20.11
CSI0_FLEX_RXN3: length 20.1
  TOP w0.089: U8.20 74.3,134.07 74.44,134.2 74.71,134.2 74.93,134.42 74.93,135.24 v1(75.25,135.56)
  BOTTOM w0.089: J20.14 72.58,148.58 72.71,148.44 72.71,147.12 76.12,143.71 76.12,135.35 75.75,134.97 75,134.97 74.87,135.11 74.87,135.51 74.97,135.62 75.18,135.62 v1(75.25,135.56)
CSI0_FLEX_RXP0: length 20.1
  TOP w0.089: v1(70.7,136.68) 70.96,136.42 70.96,136.18 70.83,136.04 U8.27
  BOTTOM w0.089: J20.3 67.08,148.62 66.94,148.49 66.94,145.29 66.63,144.98 66.25,144.98 66.01,144.74 66.01,140.55 66.25,140.32 66.63,140.32 66.94,140.01 66.94,137.83 68.78,135.99 70.84,135.99 71.06,136.21 71.06,136.88 70.97,136.97 70.79,136.97 70.7,136.87 v1(70.7,136.68)
CSI0_FLEX_RXP1: length 20.1
  TOP w0.089: U8.25 71.83,136.04 71.96,136.18 71.96,137.44 72.37,137.85 72.37,138.45 v1(72.07,138.75)
  BOTTOM w0.089: v1(72.07,138.75) 72.07,138.92 72.17,139.03 72.32,139.03 72.44,138.9 72.44,138.36 72.31,138.23 68.94,138.23 68.44,138.73 68.44,140.7 68.85,141.11 68.85,142.54 68.44,142.94 68.44,143.51 68.83,143.9 68.83,145.71 68.44,146.1 68.44,148.51 68.58,148.65 J20.6
CSI0_FLEX_RXP2: length 20.1
  TOP w0.089: U8.23 72.83,136.04 72.96,136.18 72.96,137.28 73.37,137.69 74.22,137.69 v1(74.46,137.92)
  BOTTOM w0.089: J20.12 71.58,148.6 71.44,148.47 71.44,146.89 73.87,144.46 73.87,142.43 74.08,142.22 74.71,142.22 75.05,141.87 75.05,141.38 74.71,141.04 74.08,141.04 73.87,140.83 73.87,140.53 74.08,140.31 74.71,140.31 75.05,139.97 75.05,139.48 74.71,139.13 74.08,139.13 73.87,138.92 73.87,137.78 73.99,137.66 74.2,137.66 v1(74.46,137.92)
CSI0_FLEX_RXP3: length 20.1
  TOP w0.089: v1(74.49,135.56) 74.71,135.34 74.71,134.52 74.62,134.43 74.44,134.43 74.3,134.57 U8.21
  BOTTOM w0.089: J20.15 73.08,148.6 72.94,148.47 72.94,147.21 76.35,143.8 76.35,135.25 75.84,134.74 74.91,134.74 74.64,135.02 74.64,135.4 v1(74.49,135.56)
CSI0_MIPI_RXCLKN: length 13.7
  TOP w0.089: U8.37 65.83,136.04 65.69,136.18 65.69,136.48 65.38,136.79 63.07,136.79 62.28,137.58 62.28,140.56 63.09,141.37 65.7,141.37 65.94,141.61 65.94,141.88 66.08,142.02 J1.7
CSI0_MIPI_RXCLKP: length 13.7
  TOP w0.089: U8.38 65.33,136.04 65.46,136.18 65.46,136.39 65.28,136.57 62.97,136.57 62.06,137.48 62.06,140.66 63,141.6 65.6,141.6 65.71,141.7 65.71,141.88 65.58,142.02 J1.5
CSI0_MIPI_RXN0: length 13.7
  TOP w0.089: J1.11 67.58,142.02 67.44,141.88 67.44,141.14 66.63,140.33 63.9,140.33 63.37,139.8 63.37,138.6 64.14,137.82 66.11,137.82 66.69,137.24 66.69,136.18 66.83,136.04 U8.35
CSI0_MIPI_RXN1: length 13.7
  TOP w0.089: J1.15 69.08,142.02 68.94,141.88 68.94,141.17 67.12,139.34 64.71,139.34 64.58,139.22 64.58,138.83 64.72,138.7 67,138.7 67.69,138.01 67.69,136.18 67.83,136.04 U8.33
CSI0_MIPI_RXN2: length 13.7
  TOP w0.089: U8.31 68.83,136.04 68.69,136.18 68.69,136.4 69.04,136.76 69.04,137.3 68.62,137.73 68.62,139.33 69.47,140.17 70.57,140.17 71.16,139.58 72.24,139.58 72.53,139.88 72.53,140.37 72.26,140.65 71.59,140.65 71.19,141.05 71.19,141.3 70.86,141.64 70.55,141.64 70.44,141.75 70.44,141.88 70.58,142.02 J1.19
CSI0_MIPI_RXN3: length 13.7
  TOP w0.089: J1.23 72.08,141.97 72,141.89 72,141.67 72.18,141.49 72.61,141.49 76.02,138.07 76.02,134.34 74.83,133.15 74.38,133.15 74.3,133.07 U8.18
CSI0_MIPI_RXP0: length 13.7
  TOP w0.089: J1.9 67.08,142.02 67.21,141.88 67.21,141.24 66.54,140.56 63.81,140.56 63.14,139.9 63.14,138.5 64.05,137.59 66.01,137.59 66.46,137.14 66.46,136.18 66.33,136.04 U8.36
CSI0_MIPI_RXP1: length 13.7
  TOP w0.089: U8.34 67.33,136.04 67.46,136.18 67.46,137.92 66.91,138.47 64.63,138.47 64.35,138.74 64.35,139.31 64.62,139.57 67.02,139.57 68.71,141.26 68.71,141.88 68.58,142.02 J1.13
CSI0_MIPI_RXP2: length 13.7
  TOP w0.089: J1.17 70.08,142.02 70.21,141.88 70.21,141.65 70.46,141.41 70.76,141.41 70.96,141.21 70.96,140.95 71.49,140.42 72.16,140.42 72.31,140.28 72.31,139.97 72.15,139.81 71.26,139.81 70.67,140.4 69.37,140.4 68.39,139.42 68.39,137.63 68.82,137.21 68.82,136.85 68.46,136.5 68.46,136.18 68.33,136.04 U8.32
CSI0_MIPI_RXP3: length 13.6
  TOP w0.089: J1.21 71.58,142.09 71.77,141.9 71.77,141.58 72.09,141.26 72.52,141.26 73.75,140.03 73.75,139.87 73.91,139.71 74.07,139.71 74.23,139.54 74.23,139.39 74.4,139.22 74.55,139.22 74.72,139.06 74.72,138.9 74.89,138.74 75.04,138.74 75.8,137.98 75.8,134.43 74.74,133.37 74.49,133.37 74.3,133.57 U8.19
CSI0_RXCLKN: length 54
  TOP w0.089: v1(49.29,106.02) 49.05,105.77 48.74,105.77 48.34,105.38 48.17,105.38 U18.AB14 ; v1(66.91,129.7) 66.91,129.75 67.19,130.03 67.45,130.03 67.69,130.27 67.69,131.43 67.83,131.56 U8.6
  L10_SIG03 w0.089: v1(66.91,129.7) 66.91,129.99 67,130.08 67.32,130.08 67.42,129.97 67.42,128.47 66.79,127.84 65.02,127.84 63.59,126.42 60.04,126.42 57.51,123.89 57.51,123.06 56.86,122.41 56.86,120.63 57.27,120.22 57.69,120.22 57.82,120.09 57.82,119.9 57.69,119.77 57.15,119.77 56.94,119.56 56.94,119.13 57.17,118.9 57.69,118.9 57.82,118.77 57.82,118.58 57.69,118.45 57.47,118.45 57.26,118.24 57.26,117.79 57.47,117.58 57.69,117.58 57.82,117.45 57.82,117.26 57.69,117.13 57.55,117.13 57.24,116.82 57.24,115.83 57.58,115.5 57.84,115.5 57.93,115.41 57.93,115.14 57.84,115.06 57.58,115.06 57.32,114.8 57.32,112.76 57.21,112.64 56.32,112.64 56.01,112.34 56.01,111.28 56.46,110.83 57.23,110.83 57.36,110.7 57.36,110.51 57.23,110.38 56.53,110.38 56.32,110.17 56.32,108.81 56.07,108.57 55.47,108.57 55.25,108.35 55.25,107.9 55.47,107.69 55.96,107.69 56.05,107.6 56.05,106.74 55.08,105.76 52.67,105.76 52.52,105.92 52.52,106.86 52.29,107.09 51.92,107.09 51.64,106.81 51.64,105.92 51.48,105.76 49.55,105.76 49.46,105.85 49.46,105.85 v1(49.29,106.02)
CSI0_RXCLKP: length 54
  TOP w0.089: U8.5 67.33,131.56 67.46,131.43 67.46,130.37 67.35,130.26 67.11,130.26 v1(66.91,130.46) ; v1(49.29,105.3) 49.05,105.55 48.83,105.55 48.44,105.15 48.17,105.15 U18.AB13
  L10_SIG03 w0.089: v1(66.91,130.46) 67.08,130.29 67.41,130.29 67.64,130.06 67.64,128.38 66.88,127.63 65.11,127.63 63.68,126.2 60.13,126.2 57.73,123.8 57.73,122.97 57.08,122.32 57.08,120.72 57.36,120.43 57.78,120.43 58.03,120.18 58.03,119.81 57.78,119.56 57.24,119.56 57.16,119.47 57.16,119.22 57.26,119.11 57.78,119.11 58.03,118.86 58.03,118.49 57.78,118.24 57.56,118.24 57.47,118.15 57.47,117.88 57.56,117.79 57.78,117.79 58.03,117.54 58.03,117.17 57.78,116.92 57.64,116.92 57.46,116.73 57.46,115.92 57.67,115.72 57.93,115.72 58.15,115.5 58.15,115.06 57.93,114.84 57.67,114.84 57.54,114.71 57.54,112.67 57.3,112.43 56.41,112.43 56.23,112.25 56.23,111.36 56.55,111.04 57.32,111.04 57.57,110.79 57.57,110.42 57.32,110.17 56.62,110.17 56.53,110.08 56.53,108.72 56.16,108.35 55.56,108.35 55.47,108.26 55.47,107.99 55.56,107.9 56.05,107.9 56.27,107.69 56.27,106.65 55.17,105.55 52.58,105.55 52.3,105.83 52.3,106.77 52.2,106.88 52.01,106.88 51.86,106.72 51.86,105.83 51.57,105.55 49.54,105.55 v1(49.29,105.3)
CSI0_RXN0: length 54
  TOP w0.089: U18.W12 v1(45.88,104.46) ; U8.8 68.83,131.61 68.69,131.48 68.69,130.92 v1(68.93,130.68)
  L10_SIG03 w0.089: v1(45.88,104.46) 46.07,104.27 46.07,104.04 46.41,103.7 47.17,103.7 48.36,102.52 57.35,102.52 62.82,107.98 62.82,108.88 65.57,111.63 65.57,114.09 66.26,114.79 66.26,122.56 67.85,124.15 69.48,124.15 72.07,126.74 72.07,130.41 71.71,130.78 71,130.78 70.41,130.18 69.91,130.18 69.82,130.27 69.5,130.27 69.4,130.18 68.77,130.18 68.67,130.29 68.67,130.57 68.78,130.68 v1(68.93,130.68)
CSI0_RXN1: length 54
  TOP w0.089: v1(69.46,129.35) 69.22,129.59 69.22,129.89 70.19,130.85 70.19,131.38 70.33,131.51 U8.11 ; U18.Y13 v1(46.68,105.26)
  L10_SIG03 w0.089: v1(69.46,129.35) 69.22,129.1 69.22,127.29 67.95,126.03 65.16,126.03 63.56,124.43 62.26,124.43 62.13,124.3 62.13,123.78 61.86,123.51 61.52,123.51 61.25,123.78 61.25,124.3 61.12,124.43 59.72,124.43 59.12,123.83 59.12,122.84 59.31,122.65 59.31,121.2 59.44,121.07 60.42,121.07 60.65,120.84 60.65,120.48 60.37,120.2 59.58,120.2 59.49,120.11 59.49,113.96 58.58,113.05 58.58,110.86 58.79,110.65 58.79,109.12 58.54,108.87 57.64,108.87 57.51,108.74 57.51,108.55 57.64,108.42 58.54,108.42 58.79,108.17 58.79,107.69 55.45,104.35 49.3,104.35 47.99,105.66 47.29,105.66 47.09,105.47 46.88,105.47 v1(46.68,105.26)
