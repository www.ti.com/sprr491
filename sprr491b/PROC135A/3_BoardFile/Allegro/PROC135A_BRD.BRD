# Allegro board PROC135A_BRD.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MCU_INTN: length 36
  TOP w0.132: U18.E11 v1(33.88,102.87)
  TOP w0.14: R123.1 27.15,83.58 27.48,83.25 27.48,82.42 v1(27.69,82.21)
  L10_SIG03 w0.102: v1(33.88,102.87) 33.48,103.27 31.3,103.27 30.95,102.91 29.22,102.91 28.6,102.3 28.17,102.3 26.46,100.59 24.71,100.59 24.43,100.32 v1(23.46,100.32)
  BOTTOM w0.14: v1(23.46,100.32) 25.97,100.32 26.38,99.91 26.38,99.22 27.46,98.14 27.46,95.69 26.98,95.21 26.98,91.27 27.69,90.56 v1(27.69,82.21)
MCU_MCAN0_RX: length 48.8
  TOP w0.132: U18.E8 v1(33.88,100.47)
  L03_SIG01 w0.102: v1(38.69,71.01) 38.45,70.77 38.45,66.02 J8.22
  L10_SIG03 w0.102: v1(38.69,71.01) 34.4,71.01 29.33,76.08 28.84,76.08 27.63,77.29 27.63,81.49 26.92,82.2 26.92,94.89 30.5,98.47 32.5,98.47 32.68,98.65 32.68,99.03 32.92,99.27 33.25,99.27 33.48,99.5 33.48,100.06 v1(33.88,100.47)
MCU_MCAN0_TX: length 46.1
  TOP w0.132: U18.C7 v1(32.28,99.67)
  L05_SIG02 w0.102: J8.16 31.35,65.49 30.76,65.49 30.45,65.81 29.39,65.81 28.35,66.85 28.35,69.65 24.48,73.52 24.48,91.55 24.72,91.78 24.72,94.89 25.87,96.05 25.87,98.32 26.59,99.04 29.15,99.04 30.17,100.07 31.88,100.07 v1(32.28,99.67)
MCU_OSC0_XI: length 5.3
  TOP w0.14: U18.A12 30.35,104.8 27.68,104.8 27.39,105.09 R69.2
MCU_OSC0_XO: length 5.3
  TOP w0.14: U18.A11 30.5,103.26 30.08,103.69 27.49,103.69 27.14,104.04 R77.2 R74.2
MCU_PORZ: length 89.9
  TOP w0.132: U18.A7 v1(30.68,99.67)
  TOP w0.14: TP69.1 56.48,38.62 v1(57.14,38.62) 57.14,38.22 R184.1
  L05_SIG02 w0.102: v1(30.68,99.67) 30.25,99.67 29.39,98.81 26.69,98.81 26.1,98.23 26.1,95.91 25,94.8 25,91.49 24.72,91.21 24.72,82.22 25.55,81.39 25.55,80.37 25.92,80 26.9,80 28.1,78.8 30.49,78.8 31.35,77.94 38.92,77.94 48.77,68.09 48.77,51.29 49.88,50.18 49.88,46.18 51.75,44.31 51.75,42.13 52.92,40.96 54.35,40.96 56.69,38.62 v1(57.14,38.62)
  BOTTOM w0.14: U96.4 R454.2 57.01,38.49 v1(57.14,38.62)
MCU_RESETSTATZ: length 74.5
  TOP w0.132: U18.D14 v1(33.08,106.07)
  TOP w0.14: TP45.1 42.25,61.3 J8.23
  L05_SIG02 w0.102: v1(33.08,106.07) U18.D14 33.48,104.04 32.68,103.24 32.68,102.67 32.48,102.47 30.51,102.47 29.65,101.6 29.18,101.6 28.83,101.26 27.66,101.26 26.96,100.56 25.77,100.56 23.92,98.7 23.92,97.23 23.47,96.79 23.47,95.59 23.22,95.35 22.55,95.35 22.38,95.18 22.38,94.8 22.6,94.58 23.09,94.58 23.28,94.39 23.28,92.07 23.76,91.59 23.76,71.23 26.19,68.8 26.19,66.41 26.75,65.85 27.64,65.85 28.12,65.37 28.12,64.1 28.86,63.36 32.54,63.36 33.2,62.7 33.2,60.44 33.52,60.12 33.9,60.12 34.88,61.1 41.3,61.1 42.25,62.04 J8.23
MCU_RESETZ: length 127.7
  TOP w0.132: U18.C12 v1(32.28,104.46)
  TOP w0.14: v1(38.72,24.11) 38.98,24.37 TP80.1
  L03_SIG01 w0.102: v1(22.51,101.66) 21.63,100.79 19.16,100.79 18.8,100.43 18.8,96.09 17.68,94.97 17.68,91.37 17.5,91.19 16.36,91.19 15.21,90.04 14.54,90.04 12.89,88.39 12.89,85.34 10.58,83.03 10.58,80.69 10.58,77.25 11.06,76.76 12.57,76.76 13.58,75.75 15.99,75.75 17.14,74.6 17.14,73.69 18.36,72.47 18.36,65.26 18.08,64.98 18.08,60.08 20.16,57.99 21.08,57.99 22.63,56.44 22.63,54.06 23.95,52.74 23.95,51.94 23.21,51.2 23.21,50.28 22.74,49.81 22.74,48.67 22.41,48.33 22.41,41.24 23.86,39.79 23.86,34.21 22.78,33.13 22.78,25.34 23.77,24.36 v1(23.77,22.71)
  L05_SIG02 w0.102: v1(22.51,101.66) 23.01,101.66 24.9,103.55 28.7,103.55 29.02,103.23 30.64,103.23 31,103.58 31.77,103.58 32.28,104.09 v1(32.28,104.46)
  L10_SIG03 w0.102: v1(23.77,22.71) 24.34,23.28 28.76,23.28 29.33,23.84 38.45,23.84 v1(38.72,24.11)
  BOTTOM w0.14: U108.7 39.49,23.09 39.34,23.24 R505.2 38.85,23.63 38.72,23.76 v1(38.72,24.11)
MCU_SAFETY_ERRORZ_1V8: length 48.6
  TOP w0.132: U18.B8 v1(31.48,100.47)
  TOP w0.14: v1(22.29,126.72) 24.95,126.72 25.61,126.06 26.63,126.06 27,126.43 31.77,126.43 32.13,126.06 TP9.1 31.87,125.13 31.5,125.13 31.38,125.02 U10.3
  BOTTOM w0.14: v1(31.48,100.47) 30.6,100.47 29.81,101.25 27.42,101.25 26.64,102.04 24.83,102.04 24.07,102.8 24.07,103.74 22.34,105.47 22.34,109.2 23.09,109.95 23.09,114.07 22.76,114.4 22.29,114.4 22.01,114.68 22.01,117.37 22.24,117.6 22.86,117.6 23.36,118.1 23.36,120.52 23.46,120.62 23.46,122 22.82,122.63 22.82,126.19 v1(22.29,126.72)
MCU_SAFETY_ERRORZ_3V3: length 125.6
  TOP w0.132: v1(18.71,83.17) 18.71,83.77 U27.18
  TOP w0.14: v1(26.88,125.67) 27.33,125.21 27.9,125.21 28.09,125.02 U10.6
  L03_SIG01 w0.102: v1(9.25,87.49) 9.25,90.82 10.62,92.19 14.45,92.19 15.78,93.52 15.78,95.71 12.96,98.54 12.96,102.43 13.88,103.36 13.88,104.33 11.7,106.51 11.7,109.66 12.95,110.9 12.95,111.64 17.99,116.68 17.99,121.29 22.37,125.67 v1(26.88,125.67)
  L05_SIG02 w0.102: J8.26 43.47,63.44 43.47,61.32 42.89,60.73 35.73,60.73 34.58,59.59 19.74,59.59 18.13,61.2 18.13,65.63 18.45,65.95 18.45,67.68 19.48,68.72 19.48,70.5 18.85,71.13 18.85,73.8 19.6,74.55 19.6,76.57 19.13,77.04 19.13,82.78 18.74,83.17 v1(18.71,83.17)
  BOTTOM w0.14: v1(9.25,87.49) 13.3,83.44 13.3,82.68 14.06,81.92 17.7,81.92 18.11,82.33 18.11,82.57 v1(18.71,83.17)
MCU_SPI0_CLK: length 72.6
  TOP w0.132: U18.B13 v1(31.48,105.26)
  TOP w0.14: v1(32.63,60.61) 33.34,61.31 33.34,63.47 J8.18
  L05_SIG02 w0.102: v1(32.63,60.61) 32.16,60.14 22.09,60.14 20.64,61.58 20.64,65.71 20.15,66.2 20.15,67.18 20.68,67.71 20.68,70.65 21.06,71.03 21.06,74.28 20.45,74.89 20.45,88.43 19.6,89.28 19.6,100 20.71,101.1 20.71,102.07 21.29,102.66 21.82,102.66 23.48,104.32 29.16,104.32 29.43,104.6 30.91,104.6 31.48,105.17 v1(31.48,105.26)
MCU_SPI0_CS1: length 44.4
  L05_SIG02 w0.102: J8.8 21.93,66.24 22.8,67.11 22.8,70.57 21.92,71.44 21.92,74.89 21.25,75.57 21.25,95.09 21.6,95.43 21.6,99.79 24.4,102.6 25.52,102.6 v1(25.95,103.03)
  BOTTOM w0.14: R580.1 24.91,104.07 v1(25.95,103.03)
MCU_SPI0_CS1_R: length 9.1
  TOP w0.132: U18.C11 v1(32.28,102.87)
  BOTTOM w0.14: R580.2 26.08,105.72 27.09,104.7 30.44,104.7 v1(32.28,102.87)
MCU_SPI0_D0: length 59.4
  TOP w0.132: U18.A15 v1(30.68,106.86)
  TOP w0.14: J8.6 18.83,65.32 18.83,67.77 18.51,68.09 17.31,68.09 v1(17.04,68.36)
  L05_SIG02 w0.102: v1(17.04,68.36) 15.89,68.36 15.47,68.78 15.47,73.97 14.85,74.59 14.85,75.19 15.27,75.6 15.74,75.6 16.23,76.1 16.23,76.91 16.01,77.13 16.01,82.51 15.83,82.7 15.83,83.38 15.36,83.85 15.36,88.08 15.89,88.62 15.89,92.74 16.15,93 16.15,95.44 15.29,96.3 15.29,98.06 16.44,99.21 16.44,101.48 20.2,105.24 21.44,105.24 22.69,106.49 30.31,106.49 v1(30.68,106.86)
MCU_SPI0_D1: length 56
  TOP w0.132: U18.B12 v1(31.48,104.46)
  TOP w0.14: J8.4 17.99,63.62 20.21,63.62 20.59,64 v1(20.59,66.95)
  L05_SIG02 w0.102: v1(31.48,104.46) 31.16,104.46 30.42,103.73 29.31,103.73 29.02,104.01 23.6,104.01 21.87,102.28 21.36,102.28 21.02,101.94 21.02,100.9 20.45,100.33 20.45,97.07 19.95,96.58 19.95,89.36 20.75,88.56 20.75,75.1 21.36,74.49 21.36,70.91 20.98,70.52 20.98,67.35 v1(20.59,66.95)
MCU_UART0_CTS: length 78
  TOP w0.132: U18.B11 v1(31.48,102.87)
  TOP w0.14: U33.9 55.15,67.81 v1(54.5,68.46)
  L05_SIG02 w0.102: v1(25.31,66.41) 25.31,69.15 23.53,70.92 23.53,91.35 22.42,92.46 22.42,94.41 22.15,94.68 22.15,95.85 22.75,96.45 22.75,97.85 25.68,100.79 26.66,100.79 28.06,102.18 28.95,102.18 29.2,101.94 29.63,101.94 30.38,102.69 31.3,102.69 v1(31.48,102.87)
  L10_SIG03 w0.102: v1(54.5,68.46) 54,67.96 54,67.58 53.19,66.76 48.02,66.76 47.37,66.12 29.6,66.12 28.85,66.87 25.76,66.87 v1(25.31,66.41)
MCU_UART0_CTS_3V3: length 64.3
  TOP w0.14: U33.11 53.85,67.81 v1(53.2,68.46)
  L03_SIG01 w0.102: v1(32.18,19.29) 32.18,22.37 34.78,24.96 34.78,25.95 36.55,27.73 36.55,32.7 37.34,33.49 38.05,33.49 39.91,35.35 40.77,35.35 42.06,36.63 42.06,37.46 44.47,39.87 44.47,46.41 45.23,47.17 45.23,52.31 47.11,54.19 47.11,59.95 50.68,63.52 50.68,66.77 52.37,68.46 v1(53.2,68.46)
  BOTTOM w0.14: U110.9 30.41,19.15 30.64,18.92 31.21,18.92 31.57,19.29 v1(32.18,19.29)
MCU_UART0_CTS_CONN: length 30
  TOP w0.14: U33.10 v1(54.5,67.54)
  L10_SIG03 w0.102: v1(54.5,67.54) 53.41,66.46 48.03,66.46 47.44,65.86 28.11,65.86 J8.12
MCU_UART0_MUX_OE: length 3
  TOP w0.14: R141.1 50.86,64.72 51.25,65.11 U33.15
MCU_UART0_MUX_SEL: length 44.8
  TOP w0.14: v1(51.97,64.1) 50.7,64.1 49.56,62.96 R144.2 50.36,62.08 50.6,61.84 U33.1
  L03_SIG01 w0.102: J10.2 76.57,57.46 76.53,57.41 76.38,57.41 75.26,58.54 70.82,58.54 63.35,66 63.35,67.37 61.95,68.77 58.24,68.77 55.91,66.43 53.04,66.43 51.97,65.37 v1(51.97,64.1)
MCU_UART0_RTS: length 66
  TOP w0.132: U18.D10 v1(33.08,102.07)
  TOP w0.14: U33.12 v1(53.2,67.54)
  L10_SIG03 w0.102: v1(33.08,102.07) 32.68,101.67 30.34,101.67 28.56,99.89 28.56,98.91 27.17,97.52 26.55,97.52 25.88,96.84 25.88,94.04 25.3,93.47 25.3,87.34 24.48,86.52 24.48,75.02 29.92,69.58 51.16,69.58 v1(53.2,67.54)
MCU_UART0_RTS_3V3: length 59.5
  TOP w0.14: v1(52.12,67.63) 51.9,67.4 U33.14
  L03_SIG01 w0.102: v1(33.15,19.83) 33.8,20.48 33.8,23.38 35.87,25.44 35.87,25.67 39.04,28.84 39.04,32.8 42.29,36.06 42.29,37.29 44.74,39.74 44.74,46.31 45.46,47.02 45.46,52.11 47.41,54.06 47.41,59.85 50.93,63.37 50.93,66.43 v1(52.12,67.63)
  BOTTOM w0.14: v1(33.15,19.83) 32.77,19.83 32.36,20.23 U110.7
MCU_UART0_RTS_CONN: length 20.4
  TOP w0.14: U33.13 v1(52.55,64.83)
  L10_SIG03 w0.102: v1(52.55,64.83) 51.81,64.83 50.6,63.62 36.03,63.62 J8.17
MCU_UART0_RX_3V3: length 57.6
  TOP w0.14: U33.2 51.25,62.1 v1(51.92,62.78)
  L03_SIG01 w0.102: v1(51.92,62.78) 50.77,62.78 47.69,59.7 47.69,53.92 45.71,51.94 45.71,46.85 45,46.14 45,39.67 42.55,37.22 42.55,35.89 39.37,32.71 39.37,28.66 36.55,25.85 36.55,22.77 35.21,21.43 34.37,21.43 34.11,21.17 34.11,19.6 v1(33.83,19.32)
  BOTTOM w0.14: v1(33.83,19.32) 32.87,19.32 32.36,19.83 U110.8
MCU_UART0_RXD: length 69
  TOP w0.132: U18.D8 v1(33.08,100.47)
  TOP w0.14: v1(52.91,62.78) 52.91,61.94 52.55,61.57 U33.4
  L10_SIG03 w0.102: v1(33.08,100.47) 33.08,100.3 32.68,99.9 32.68,99.5 32.45,99.26 30.31,99.26 30.01,98.96 30.01,98.4 26.63,95.02 26.63,82.09 27.32,81.41 27.32,77.23 28.79,75.76 29.21,75.76 34.34,70.63 53.26,70.63 54.99,68.9 55.12,68.76 55.12,64.16 53.74,62.78 v1(52.91,62.78)
MCU_UART0_RXD_CONN: length 24.4
  TOP w0.14: v1(51.9,61.89) U33.3
  L10_SIG03 w0.102: v1(51.9,61.89) 48.52,61.89 47.7,61.08 30.69,61.08 J8.13
MCU_UART0_TX_3V3: length 55.2
  TOP w0.14: U33.5 v1(53.2,59.31)
  L03_SIG01 w0.102: v1(34.67,20.99) 35.36,20.99 36.81,22.44 36.81,25.52 39.7,28.41 39.7,32.72 42.8,35.82 42.8,37.15 45.23,39.58 45.23,46.05 45.93,46.75 45.93,51.79 47.92,53.77 47.92,58.78 49.58,60.44 52.07,60.44 v1(53.2,59.31)
  BOTTOM w0.14: v1(34.67,20.99) R523.2 32.46,20.99 32.1,20.63 U110.6
MCU_UART0_TXD: length 71.2
  TOP w0.132: U18.F8 v1(34.68,100.47)
  TOP w0.14: U33.7 54.5,63.12 v1(53.95,63.67)
  L10_SIG03 w0.102: v1(34.68,100.47) 34.28,100.86 32.91,100.86 32.68,100.63 32.68,100.59 32.68,100.3 32.45,100.07 32.4,100.07 30.39,100.07 29.72,99.39 29.72,98.57 26.4,95.25 26.4,83.86 25.56,83.01 25.56,78.53 28.59,75.5 29.08,75.5 34.21,70.38 53.18,70.38 54.89,68.67 54.89,64.61 v1(53.95,63.67)
MCU_UART0_TXD_CONN: length 19.7
  TOP w0.14: v1(52.89,63.64) 53.85,62.68 U33.6
  L10_SIG03 w0.102: J8.19 38.31,63.36 51.41,63.36 51.69,63.64 v1(52.89,63.64)
MFP0: length 2.8
  TOP w0.14: R152.1 v1(76.19,53.02)
  BOTTOM w0.14: R152.1 v1(76.19,53.02) 76.19,52.6 75.66,52.07 U88.45
MFP1: length 4.3
  TOP w0.14: v1(77.61,53.04) 77.21,53.04 77.1,53.15 R153.1
  BOTTOM w0.14: U88.46 76.16,52.14 77.07,53.04 v1(77.61,53.04) 77.61,53.35 77.38,53.58 R153.1
MFP2: length 2.9
  TOP w0.14: TP55.1 v1(78.11,52.47)
  BOTTOM w0.14: U88.47 76.66,52.14 76.99,52.47 v1(78.11,52.47)
MFP3: length 3.2
  TOP w0.14: TP54.1 v1(78.84,52.67)
  BOTTOM w0.14: U88.48 77.16,51.82 77.38,52.05 78.57,52.05 78.84,52.31 v1(78.84,52.67)
MIC_IN: length 10.5
  TOP w0.254: J14.1 82.88,40.54 81.09,42.32 v1(79.34,42.32)
  BOTTOM w0.254: U88.12 78.19,45.29 78.63,44.86 R437.1 C426.1 v1(79.34,42.32)
MMC0_CLK: length 29.6
  TOP w0.14: U28.M6 57.42,77.26 v1(57.67,77.51)
  L05_SIG02 w0.102: v1(50.73,100.64) 50.73,100.4 51.5,99.62 51.81,99.62 52.14,99.29 52.14,97.62 54.52,95.24 54.52,89.83 58.61,85.75 58.61,79.14 58.3,78.84 58.3,78.14 v1(57.67,77.51)
  BOTTOM w0.14: R371.1 57.85,77.69 v1(57.67,77.51) 57.48,77.32 R373.2 ; v1(50.73,100.64) 50.27,100.17 R343.1
MMC1_CLK: length 53.8
  TOP w0.14: R98.1 6.74,95.15 v1(6.74,95.64) 6.98,95.64 7.42,96.07 U22.6
  L05_SIG02 w0.102: v1(6.74,95.64) 7.04,95.93 7.04,103.65 7.5,104.1 7.5,106.31 8.79,107.61 8.79,115.47 11.56,118.24 16.62,118.24 16.82,118.44 30.22,118.44 v1(32.37,116.29)
  BOTTOM w0.14: R321.1 R315.1 33.88,114.78 v1(32.37,116.29) ; J22.5 6.03,96.36 v1(6.74,95.64)
MMC1_CLK_R: length 1.2
  TOP w0.132: U18.E22 v1(33.88,112.46)
  BOTTOM w0.14: R321.2 v1(33.88,112.46)
MMC1_CMD: length 55.6
  TOP w0.132: U18.C21 v1(32.28,111.66)
  TOP w0.14: U22.1 8.92,98.19 8.89,98.21 v1(8.89,98.26) 8.89,98.31 9.02,98.44 R90.1
  L05_SIG02 w0.102: v1(32.28,111.66) 31.88,112.06 27.34,112.06 26.99,112.41 26.99,112.94 26.86,113.07 26.61,113.07 26.48,113.21 26.48,113.4 26.61,113.53 26.86,113.53 26.99,113.66 26.99,114.31 26.8,114.5 25.69,114.5 25.57,114.62 25.57,115.01 25.45,115.12 25.22,115.12 25.1,115 25.1,114.62 24.98,114.5 23.82,114.5 23.7,114.62 23.7,114.97 23.58,115.09 23.33,115.09 23.19,114.96 23.19,114.66 23.07,114.53 19.62,114.53 19.47,114.38 19.47,114.03 19.35,113.91 19.18,113.91 19.06,114.03 19.06,114.38 18.94,114.5 18.78,114.5 18.66,114.38 18.66,114.03 18.54,113.91 18.37,113.91 18.25,114.03 18.25,114.51 17.78,114.98 15.67,114.98 14.72,114.02 14.53,114.02 13.89,114.65 13.7,114.65 13.57,114.52 13.57,114.33 14.2,113.69 14.2,113.5 13.11,112.41 13.11,112.22 13.49,111.83 13.49,111.61 13.29,111.41 13.15,111.41 12.7,111.86 12.56,111.86 12.2,111.5 12.2,110.7 11.97,110.47 11.15,110.47 11.02,110.33 11.02,110.11 11.12,110.01 11.35,110.01 11.45,109.91 11.45,109.68 11.35,109.58 10.69,109.58 10.59,109.49 10.59,109.15 10.71,109.03 11.08,109.03 11.2,108.91 11.2,108.74 11.08,108.63 10.71,108.63 10.59,108.51 10.59,107.67 8.74,105.82 8.74,100.09 8.89,99.94 v1(8.89,98.26)
  BOTTOM w0.14: J22.3 5.82,98.56 6.65,97.73 8.36,97.73 v1(8.89,98.26)
MMC1_D0: length 55.9
  TOP w0.132: U18.B22 v1(31.48,112.46)
  TOP w0.14: U22.8 8.42,95.64 8.58,95.48 v1(8.58,95.43) 8.58,95.14 R100.1
  L05_SIG02 w0.102: v1(8.58,95.43) 8.58,94.77 8.3,94.49 7.37,94.49 7.21,94.66 7.21,94.87 7.33,94.99 7.96,94.99 8.18,95.21 8.18,95.77 8.49,96.08 8.49,98.67 8,99.15 8,103.24 8.44,103.67 8.44,105.94 10.29,107.8 10.29,110.04 12.48,112.23 12.48,112.42 11.93,112.97 11.93,113.16 12.06,113.29 12.25,113.29 12.8,112.74 12.99,112.74 13.63,113.38 13.63,113.64 13.12,114.15 13.12,114.53 13.86,115.27 14.36,115.27 14.74,114.89 15.14,114.89 15.57,115.32 17.81,115.32 18.03,115.54 26.4,115.54 27.34,114.6 27.34,113.57 28.47,112.44 29.84,112.44 30.28,112.88 30.87,112.88 31.08,112.68 31.27,112.68 v1(31.48,112.46)
  BOTTOM w0.14: J22.7 6.17,94.16 7.23,95.21 7.23,95.66 7.51,95.94 8.07,95.94 v1(8.58,95.43)
MMC1_D1: length 56.3
  TOP w0.132: U18.D21 v1(33.08,111.66)
  TOP w0.14: R99.1 7.92,95.3 7.78,95.44 ; v1(7.77,95.44) 7.78,95.44 ; 7.78,95.44 7.92,95.58 U22.7
  L05_SIG02 w0.102: v1(7.77,95.44) 7.37,95.84 7.37,96.27 7.57,96.47 7.57,96.72 7.37,96.93 7.37,97.24 7.58,97.45 7.58,97.69 7.37,97.91 7.37,103.54 7.81,103.98 7.81,106.18 9.1,107.47 9.1,113.64 11.08,115.63 11.08,116.07 12.75,117.74 16.66,117.74 16.97,117.44 29.93,117.44 33.06,114.31 33.06,113.19 32.68,112.8 32.68,112.06 v1(33.08,111.66)
  BOTTOM w0.14: J22.8 6.42,93.06 7.77,94.4 v1(7.77,95.44)
MMC1_D2: length 55.8
  TOP w0.132: U18.C22 v1(32.28,112.46)
  TOP w0.14: R91.1 8.21,98.39 v1(8.08,98.26) 8.42,97.92 U22.2
  L05_SIG02 w0.102: v1(32.28,112.46) 31.74,113 31.24,113 30.61,113.64 30.61,115.04 30.23,115.42 30.23,115.68 30.5,115.94 30.5,116.18 30.31,116.37 30.08,116.37 29.78,116.07 29.58,116.07 28.68,116.97 28.15,116.97 27.93,116.75 27.93,115.29 27.74,115.09 27.54,115.09 27.36,115.27 27.36,116.3 27.16,116.5 18.06,116.5 17.72,116.16 16.05,116.16 15.92,116.28 15.92,117.05 15.79,117.17 15.62,117.17 15.49,117.05 15.49,116.28 15.36,116.16 15.18,116.16 15.06,116.28 15.06,117.05 14.93,117.17 14.75,117.17 14.63,117.05 14.63,116.28 14.5,116.16 14.21,116.16 11.13,113.08 11.13,112.75 9.4,111.02 9.4,107.34 8.12,106.06 8.12,103.82 7.67,103.37 7.67,98.67 v1(8.08,98.26)
  BOTTOM w0.14: J22.1 6.05,100.76 8.08,98.73 v1(8.08,98.26)
MMC1_D3: length 57.4
  TOP w0.132: U18.D22 v1(33.08,112.47)
  TOP w0.14: v1(6.52,99.13) 6.86,98.79 R92.1 7.14,98.57 7.92,97.79 U22.3
  L05_SIG02 w0.102: v1(6.52,99.13) 6.52,104.7 6.23,104.99 6.23,109.4 8.44,111.6 8.44,116.53 11.28,119.38 11.93,119.38 12.06,119.25 12.06,118.89 12.2,118.76 12.39,118.76 12.52,118.89 12.52,119.25 12.66,119.38 12.84,119.38 12.98,119.25 12.98,118.89 13.11,118.76 13.3,118.76 13.44,118.89 13.44,119.25 13.57,119.38 16.74,119.38 16.86,119.5 26.93,119.5 27.06,119.37 27.06,119.18 27.19,119.05 27.36,119.05 27.49,119.18 27.49,119.37 27.62,119.5 27.8,119.5 27.92,119.37 27.92,119.18 28.05,119.05 28.23,119.05 28.35,119.18 28.35,119.37 28.48,119.5 29.92,119.5 32.82,116.6 32.82,114.99 33.37,114.44 33.37,113.01 33.08,112.72 v1(33.08,112.47)
  BOTTOM w0.14: J22.2 5.99,99.66 v1(6.52,99.13)
MMC1_SD_EN: length 107
  TOP w0.14: v1(1.63,87.52) 1.63,87.82 1.77,87.96 2.43,87.96 2.62,88.15 2.62,89.1 2.99,89.47 5.61,89.47 5.92,89.79 R106.1
  L05_SIG02 w0.102: v1(17.14,39.24) 16.45,38.55 14.49,38.55 12.77,40.27 12.77,53.51 12.37,53.91 10.95,53.91 10.24,54.62 6.65,54.62 1.38,59.89 1.38,63.83 2.26,64.71 2.26,71.46 1.68,72.05 1.68,74.08 2.09,74.49 2.09,76.44 1.44,77.08 1.44,87.33 v1(1.63,87.52)
  L10_SIG03 w0.102: v1(17.14,39.24) 17.42,38.96 19.89,38.96 20.8,38.05 29.92,38.05 30.27,38.39 36.3,38.39 37.62,39.71 37.62,39.83 38.77,40.98 38.82,40.98 39.4,41.55 39.4,41.67 39.85,42.12 39.96,42.12 40.57,42.72 40.57,42.75 41.06,43.25 44.14,43.25 44.96,42.42 44.96,42.2 45.59,41.57 v1(49.86,41.57)
  BOTTOM w0.14: U92.4 50.91,42.61 v1(49.86,41.57)
MMC1_SD_LS_EN: length 21.9
  TOP w0.14: R105.2 6.82,92.7 v1(6.81,92.69) 6.49,92.37 U24.4 ; v1(10.55,103.41) R79.1 U20.3
  L03_SIG01 w0.102: v1(6.81,92.69) 6.36,93.14 3.06,93.14 1.98,94.22 1.98,96.11 9.28,103.41 v1(10.55,103.41)
MMC1_SDCARD_EN: length 33.4
  TOP w0.14: R105.1 7.85,93.16 7.71,93.3 v1(7.4,93.3)
  L05_SIG02 w0.102: v1(7.4,93.3) 7.4,92.48 6.34,91.42 6.34,90.94 6.14,90.74 6.14,86.71 8.09,84.77 8.09,81.46 7.69,81.06 7.69,78.74 5.81,76.86 v1(5.81,76.79)
  BOTTOM w0.14: v1(5.81,76.79) 10.27,76.79 11.49,78.02 12.65,78.02 13.76,76.91 16.7,76.91 17.74,75.87 R374.1
MMC1_SDCD: length 32.5
  TOP w0.132: U18.E18 v1(33.88,109.26)
  TOP w0.14: R97.1 v1(22.9,94.96)
  L05_SIG02 w0.102: v1(22.9,94.96) 23.5,94.96 23.81,95.27 23.81,96.72 24.51,97.42 24.51,98.97 25.86,100.32 28.52,100.32 29.53,101.33 29.99,101.33 30.33,101.67 32.5,101.67 32.68,101.84 32.68,102.27 32.88,102.47 33.3,102.47 33.48,102.65 33.48,103.46 34.28,104.26 34.28,108.63 33.88,109.03 v1(33.88,109.26)
  BOTTOM w0.14: v1(22.9,94.96) 22.63,95.23 22.63,95.31 22.32,95.63 21.08,95.63 20.45,96.26 19.26,96.26 18.61,95.61 17.21,95.61 16.97,95.37 U79.5 16.06,95.03 J22.9
MMC2_CLK: length 63.2
  L05_SIG02 w0.102: v1(33.96,118.98) 29.71,123.22 27.08,123.22 26.62,122.76 21.52,122.76 20.98,123.3 20.98,124.36 18.28,127.06 18.28,131.45 20.04,133.21 20.04,133.83 23.16,136.95 26.35,136.95 28.62,139.21 28.62,140.35 29.81,141.54 v1(29.81,149.6)
  BOTTOM w0.14: v1(33.96,118.98) 33.96,117.52 34.65,116.83 35.13,116.83 35.61,116.35 R316.2 ; R244.1 R243.2 R242.1 25.32,152.53 R241.1 28.9,152.53 29.81,151.62 v1(29.81,149.6)
MMC2_CMD: length 66.9
  TOP w0.132: U18.G22 v1(35.48,112.46)
  L05_SIG02 w0.102: v1(17.99,138.36) 17.99,138.87 18.18,139.05 19.86,139.05 19.96,139.15 19.96,141.17 20.09,141.31 20.5,141.31 20.64,141.44 20.64,141.63 20.5,141.76 20.09,141.76 19.96,141.9 19.96,142.15 19.86,142.25 19.58,142.25 19.44,142.11 19.44,140.31 19.31,140.17 19.12,140.17 18.98,140.31 18.98,142.13 18.85,142.25 18.67,142.25 18.53,142.11 18.53,139.61 18.39,139.47 18.2,139.47 18.07,139.61 18.07,142.13 17.94,142.25 17.68,142.25 17.55,142.13 17.55,137.16 16.97,136.58 16.97,134.67 17.11,134.53 17.81,134.53 17.94,134.4 17.94,134.21 17.81,134.07 17.11,134.07 16.97,133.94 16.97,133.06 15.73,131.81 15.73,127.42 16.5,126.64 17.8,126.64 20.35,124.09 20.35,122.98 21.2,122.13 29.64,122.13 34.21,117.56 34.21,116.1 35.07,115.24 35.07,113.17 35.48,112.77 v1(35.48,112.46)
  BOTTOM w0.14: R259.2 R267.2 R275.1 v1(17.99,138.36)
MMC2_D0: length 67.3
  TOP w0.132: U18.E20 v1(33.88,110.86)
  L05_SIG02 w0.102: v1(12.91,138.36) 13.34,138.79 13.34,141.24 13.17,141.41 12.7,141.41 12.57,141.28 12.57,139.84 12.44,139.71 12.25,139.71 12.11,139.84 12.11,141.28 11.98,141.41 11.79,141.41 11.66,141.28 11.66,139.84 11.52,139.71 11.33,139.71 11.2,139.84 11.2,141.28 11.07,141.41 10.5,141.41 10.32,141.24 10.32,139.43 10.48,139.27 12.01,139.27 12.25,139.03 12.25,137.61 12.48,137.39 12.64,137.39 13.02,137.77 13.19,137.77 13.31,137.65 13.31,137.48 12.93,137.1 12.93,136.94 13.05,136.82 13.22,136.82 13.59,137.19 13.76,137.19 13.88,137.07 13.88,136.9 13.51,136.53 13.51,136.36 13.97,135.9 13.97,132.79 12.88,131.71 12.88,127.37 13.87,126.38 15.24,126.38 15.99,125.63 17.52,125.63 19.3,123.85 19.3,122.61 20.17,121.74 20.17,120.83 20.95,120.05 24.89,120.05 25.36,120.52 29.71,120.52 33.19,117.03 33.19,115.1 33.67,114.62 33.67,112.88 33.48,112.69 33.48,111.26 v1(33.88,110.86)
  BOTTOM w0.14: v1(12.91,138.36) R277.1 R269.2 R261.2
MMC2_D1: length 67.2
  TOP w0.132: U18.F21 v1(34.68,111.66)
  L05_SIG02 w0.102: v1(15.45,138.36) 15.94,138.85 15.94,139.75 16.67,140.48 16.67,142.64 16.43,142.88 14.57,142.88 14.44,142.75 14.44,142.48 14.57,142.35 16.16,142.35 16.29,142.22 16.29,142.03 16.16,141.89 14.57,141.89 14.44,141.76 14.44,141.57 14.57,141.44 16.16,141.44 16.29,141.3 16.29,141.11 16.16,140.98 14.57,140.98 14.44,140.85 14.44,140.49 14.57,140.36 15.38,140.36 15.52,140.23 15.52,140.04 15.38,139.9 14.57,139.9 14.44,139.77 14.44,138.37 14.99,137.83 15.33,137.83 15.47,137.68 15.47,137.23 15.35,137.1 14.57,137.1 14.33,136.86 14.33,132.72 13.18,131.57 13.18,127.5 13.96,126.72 15.38,126.72 16.17,125.93 17.64,125.93 19.66,123.92 19.66,122.74 20.92,121.49 29.28,121.49 33.53,117.24 33.53,115.2 33.98,114.75 33.98,112.96 34.28,112.66 34.28,112.06 v1(34.68,111.66)
  BOTTOM w0.14: v1(15.45,138.36) R276.1 R268.2 R260.2
MMC2_D2: length 67
  TOP w0.132: U18.F20 v1(34.68,110.86)
  L05_SIG02 w0.102: v1(24.54,138.36) 24.54,142.16 24.04,142.66 23.45,142.66 23.32,142.53 23.32,141.58 23.18,141.44 22.99,141.44 22.86,141.58 22.86,142.53 22.72,142.66 22.53,142.66 22.4,142.53 22.4,141.58 22.27,141.44 22.08,141.44 21.94,141.58 21.94,142.53 21.81,142.66 21.62,142.66 21.49,142.53 21.49,141.58 21.35,141.44 21.16,141.44 21.03,141.58 21.03,142.53 20.9,142.66 17.44,142.66 17.12,142.35 17.12,137.42 16.6,136.89 16.6,133.11 15.42,131.94 15.42,127.17 16.31,126.29 17.72,126.29 20.03,123.98 20.03,122.82 21.02,121.82 29.45,121.82 33.83,117.44 33.83,115.33 34.28,114.87 34.28,113.43 35.08,112.63 35.08,111.26 v1(34.68,110.86)
  BOTTOM w0.14: R258.2 R266.2 R274.1 v1(24.54,138.36)
MMC2_D3: length 67
  TOP w0.132: U18.G21 v1(35.48,111.66)
  L05_SIG02 w0.102: v1(35.48,111.66) 35.48,111.83 35.89,112.24 35.89,114.85 34.51,116.23 34.51,117.8 29.89,122.43 21.38,122.43 20.67,123.13 20.67,124.2 17.96,126.92 17.96,132.15 18.81,132.99 18.81,133.81 19.21,134.21 19.21,134.38 18.93,134.66 18.93,134.82 19.05,134.94 19.22,134.94 19.5,134.66 19.67,134.66 19.79,134.78 19.79,134.95 19.51,135.23 19.51,135.4 19.63,135.52 19.8,135.52 20.07,135.24 20.24,135.24 20.88,135.88 20.88,136.77 20.57,137.08 18.19,137.08 18.09,137.19 18.09,137.45 18.2,137.55 21.4,137.55 21.52,137.67 21.52,137.92 21.38,138.06 18.7,138.06 18.55,138.21 18.55,138.5 18.71,138.67 22.46,138.67 22.61,138.81 22.61,140.2 22.71,140.3 23.01,140.3 23.13,140.19 23.13,137.76 23.35,137.54 24.75,137.54 25.58,138.36 v1(27.08,138.36)
  BOTTOM w0.14: R257.2 R265.2 R273.1 v1(27.08,138.36)
Net_6: length 0.6
  TOP w0.132: 34.28,104.86 v1(33.88,105.26)
Net_1372: length 0.6
  TOP w0.132: 44.68,103.26 v1(45.08,102.87)
Net_1374: length 0.6
  TOP w0.132: 40.68,96.07 v1(41.08,95.67)
Net_1377: length 0.6
  TOP w0.132: 42.28,100.07 v1(42.68,99.67)
Net_1378: length 0.6
  TOP w0.132: 41.48,97.67 v1(41.88,97.26)
Net_1388: length 0.6
  TOP w0.132: 38.28,96.86 v1(37.88,96.47)
Net_1389: length 0.6
  TOP w0.132: 39.88,96.07 v1(40.28,95.67)
Net_1390: length 0.6
  TOP w0.132: 39.88,96.86 v1(40.28,96.47)
Net_1393: length 0.6
  TOP w0.132: 33.48,99.26 v1(33.08,98.87)
Net_1394: length 0.6
  TOP w0.132: 32.68,99.26 v1(32.28,98.87)
Net_1395: length 0.6
  TOP w0.132: 34.28,100.07 v1(33.88,99.67)
OSC0: length 5
  TOP w0.14: U47.88 59.17,25.25 C146.2 59.43,25.55 58.92,26.07 58.92,27.66 59.06,27.8 Y4.3
OSC1: length 3.3
  TOP w0.14: U47.89 58.77,25.17 C145.2 58.38,26.07 58.24,26.21 Y4.1
OSPI0_CSN0: length 2
  TOP w0.132: U18.H21 v1(36.28,111.66)
  BOTTOM w0.14: R320.2 v1(36.28,111.66)
OSPI0_LBCLK: length 25.2
  L05_SIG02 w0.102: v1(39.96,117.11) 39.96,115.27 40.1,115.14 40.35,115.14 40.48,115.26 40.48,117.2 40.6,117.32 40.81,117.32 40.95,117.18 40.95,115.23 41.07,115.11 41.26,115.11 41.39,115.24 41.39,116.56 41.51,116.68 42.26,116.68 42.51,116.93 42.51,117.73 42.71,117.94 50.38,117.94 v1(51.31,118.87)
  BOTTOM w0.14: v1(39.96,117.11) 39.96,115.51 R319.1 ; R312.2 v1(51.31,118.87)
OSPI0_LBCLKO_R: length 1.3
  TOP w0.132: U18.K22 v1(37.88,112.46)
  BOTTOM w0.14: v1(37.88,112.46) 37.88,112.47 37.88,112.87 R319.2
OSPI_CLK: length 27.8
  TOP w0.132: U18.L22 v1(38.68,112.46)
  L05_SIG02 w0.102: v1(48.42,119.04) 49.02,119.04 49.26,119.28 49.26,119.45 49.18,119.53 49.18,119.7 49.3,119.82 49.46,119.82 49.55,119.73 49.72,119.73 49.97,119.99 50.12,119.99 50.29,119.82 50.29,119.67 49.24,118.62 47.99,118.62 47.87,118.74 47.87,118.88 47.75,119 47.58,119 47.46,118.89 47.46,118.74 47.35,118.62 46.34,118.62 46.22,118.74 46.22,119.08 46.1,119.2 45.93,119.2 45.81,119.08 45.81,118.74 45.69,118.62 45.53,118.62 45.41,118.74 45.41,119.08 45.29,119.2 45.12,119.2 45,119.08 45,118.74 44.88,118.62 44.71,118.62 44.59,118.74 44.59,119.08 44.47,119.2 44.31,119.2 44.19,119.08 44.19,118.74 44.07,118.62 43.3,118.62 43.13,118.79 43.13,119.06 42.98,119.21 41.45,119.21 41.06,118.83 41.06,118.66 41.19,118.53 41.19,118.36 41.07,118.24 40.91,118.24 40.78,118.37 40.61,118.37 40.26,118.02 38.51,118.02 38.14,117.65 38.14,116.27 38.6,115.81 38.6,112.55 v1(38.68,112.46)
  BOTTOM w0.14: v1(48.42,119.04) R311.1 R313.1
OSPI_CS: length 27.7
  TOP w0.14: U12.C2 v1(50.35,122.4)
  L05_SIG02 w0.102: v1(36.86,118.15) 37.92,118.15 38.11,118.33 40.14,118.33 41.38,119.57 46.79,119.57 47.1,119.88 47.72,119.88 47.85,120 47.85,120.36 47.98,120.49 48.23,120.49 48.35,120.38 48.35,119.62 48.46,119.51 48.72,119.51 48.84,119.63 48.84,120.43 49.39,120.97 51.54,120.97 51.65,121.08 51.65,121.26 51.53,121.38 50.28,121.38 50.2,121.47 50.2,121.68 50.3,121.78 50.79,121.78 50.89,121.88 50.89,122.31 50.81,122.4 v1(50.35,122.4)
  BOTTOM w0.14: v1(50.35,122.4) 50.69,122.06 R304.1 ; v1(36.86,118.15) 36.86,115.97 36.28,115.4 R320.1
OSPI_DQ0: length 22.8
  TOP w0.14: RA1.2 35.86,119.39 v1(36.4,119.93) ; U12.D3 v1(49.35,123.4)
  L05_SIG02 w0.102: v1(49.35,123.4) 49.34,123.39 48.97,123.39 48.28,122.7 47.45,122.7 47.18,122.96 47.18,123.83 46.86,124.16 46.86,124.61 46.57,124.89 44.61,124.89 44.49,124.78 44.49,124.54 44.37,124.42 44.2,124.42 44.08,124.54 44.08,124.78 43.96,124.89 43.8,124.89 43.68,124.78 43.68,124.54 43.56,124.42 43.39,124.42 43.27,124.54 43.27,124.78 43.15,124.89 42.53,124.89 42.39,125.03 42.08,125.03 41.94,124.89 41.44,124.89 41.31,125.03 41.31,125.2 41.17,125.34 40.98,125.34 40.85,125.2 40.85,125.03 40.72,124.89 40.02,124.89 36.4,121.28 v1(36.4,119.93)
  BOTTOM w0.14: v1(49.35,123.4) 48.98,123.77 R299.1
OSPI_DQ1: length 19
  TOP w0.14: U12.D2 v1(50.35,123.4) ; RA2.1 38.68,118.87 v1(38.82,119.01)
  L05_SIG02 w0.102: v1(38.82,119.01) 38.82,119.29 39.35,119.82 39.35,120.29 39.79,120.73 40.77,120.73 40.89,120.61 40.89,120.4 41.01,120.28 41.18,120.28 41.3,120.4 41.3,120.61 41.42,120.73 41.59,120.73 41.71,120.61 41.71,120.4 41.83,120.28 41.99,120.28 42.11,120.4 42.11,120.61 42.23,120.73 42.4,120.73 42.52,120.61 42.52,120.4 42.64,120.28 42.81,120.28 42.93,120.4 42.93,120.61 43.04,120.73 43.21,120.73 43.33,120.61 43.33,120.4 43.45,120.28 43.62,120.28 43.74,120.4 43.74,120.61 43.86,120.73 44.03,120.73 44.14,120.61 44.14,120.4 44.26,120.28 44.43,120.28 44.55,120.4 44.55,120.61 44.67,120.73 46.01,120.73 46.44,121.16 48.69,121.16 49.63,122.09 49.63,122.66 50.35,123.39 v1(50.35,123.4)
  BOTTOM w0.14: v1(50.35,123.4) 50.57,123.18 R302.1
OSPI_DQ2: length 20.8
  TOP w0.14: RA2.2 38.28,119.39 v1(38.82,119.93) ; U12.C4 v1(48.25,121.55)
  L05_SIG02 w0.102: v1(48.25,121.55) 47.7,121.55 47.47,121.79 45.9,121.79 45.79,121.67 45.79,121.27 45.67,121.15 45.5,121.15 45.38,121.27 45.38,121.67 45.26,121.79 45.09,121.79 44.97,121.67 44.97,121.27 44.85,121.15 44.68,121.15 44.57,121.27 44.57,121.67 44.45,121.79 44.28,121.79 44.16,121.67 44.16,121.27 44.04,121.15 43.87,121.15 43.75,121.27 43.75,121.67 43.63,121.79 43.47,121.79 43.35,121.67 43.35,121.27 43.23,121.15 43.06,121.15 42.94,121.27 42.94,121.67 42.82,121.79 42.65,121.79 42.53,121.67 42.53,121.27 42.41,121.15 42.25,121.15 42.13,121.27 42.13,121.67 42.01,121.79 41.84,121.79 41.72,121.67 41.72,121.27 41.6,121.15 41.43,121.15 41.31,121.27 41.31,121.67 41.2,121.79 41.03,121.79 40.91,121.67 40.91,121.27 40.79,121.15 40.62,121.15 40.5,121.27 40.5,121.67 40.38,121.79 39.85,121.79 38.82,120.76 v1(38.82,119.93)
  BOTTOM w0.14: v1(48.25,121.55) 47.91,121.89 R303.1
OSPI_DQ3: length 20.3
  TOP w0.14: v1(34.92,119.93) 35.46,119.39 RA1.3 ; U12.D4 v1(48.35,123.4)
  L05_SIG02 w0.102: v1(34.92,119.93) 34.92,120.23 40.34,125.66 46.69,125.66 48.35,123.99 v1(48.35,123.4)
  BOTTOM w0.14: R300.1 v1(48.35,123.4)
OSPI_DQ4: length 23.1
  TOP w0.14: U12.D5 v1(46.35,123.4) ; v1(37.34,119.01) 37.48,118.87 RA2.4
  L05_SIG02 w0.102: v1(46.35,123.4) 46.1,123.14 46.1,122.87 45.96,122.73 45.67,122.73 45.57,122.84 45.57,123.2 45.37,123.4 41.39,123.4 41.27,123.28 41.27,123.11 41.39,122.99 43.32,122.99 43.43,122.88 43.43,122.71 43.3,122.58 40.98,122.58 40.86,122.7 40.86,123.28 40.74,123.4 40.45,123.4 39.54,122.49 39.37,122.49 39.07,122.79 38.91,122.79 38.79,122.67 38.79,122.5 39.09,122.2 39.09,122.04 38.97,121.92 38.8,121.92 38.5,122.22 38.33,122.22 38.21,122.1 38.21,121.93 38.51,121.63 38.51,121.46 38.39,121.34 38.22,121.34 37.92,121.64 37.76,121.64 37.64,121.52 37.64,121.35 37.94,121.05 37.94,120.89 37.77,120.72 37.77,119.44 v1(37.34,119.01)
  BOTTOM w0.14: R301.1 v1(46.35,123.4)
OSPI_DQ5: length 21.2
  TOP w0.14: v1(34.92,119.01) 35.06,118.87 RA1.4 ; U12.E3 v1(49.35,124.4)
  L05_SIG02 w0.102: v1(49.35,124.4) 48.8,124.4 47.23,125.97 40.21,125.97 34.53,120.29 34.53,119.41 v1(34.92,119.01)
  BOTTOM w0.14: R297.1 v1(49.35,124.4)
OSPI_DQ6: length 22.1
  TOP w0.14: RA2.3 37.88,119.39 v1(37.34,119.93) ; U12.E2 v1(50.35,124.4)
  L05_SIG02 w0.102: v1(50.35,124.4) 50.82,123.93 50.82,123.25 50.51,122.95 50.37,122.95 49.97,122.55 49.97,121.98 48.84,120.85 47.18,120.85 46.84,120.5 46.84,120.21 46.54,119.91 41.01,119.91 40.54,119.44 39.62,119.44 39.36,119.18 39.36,118.94 39.05,118.63 37.16,118.63 36.95,118.84 36.95,119.3 37.34,119.68 v1(37.34,119.93)
  BOTTOM w0.14: R296.1 v1(50.35,124.4)
OSPI_DQ7: length 23.7
  TOP w0.14: RA1.1 36.26,118.87 v1(36.4,119.01) ; U12.E1 v1(51.35,124.4)
  L05_SIG02 w0.102: v1(51.35,124.4) 50.84,124.91 50.15,124.91 49.81,124.58 49.81,123.31 49.34,122.83 49.04,122.83 48.53,122.31 47.24,122.31 46.79,122.76 46.79,123.55 46.44,123.9 40.87,123.9 40.75,124.01 40.75,124.24 40.63,124.36 40.47,124.36 40.35,124.24 40.35,124.01 40.23,123.9 39.47,123.9 36.83,121.26 36.83,119.74 36.4,119.3 v1(36.4,119.01)
  BOTTOM w0.14: R295.1 v1(51.35,124.4)
OSPI_DQS: length 4
  TOP w0.14: U12.C3 v1(49.23,122.27)
  BOTTOM w0.14: v1(49.23,122.27) 48.93,121.97 R306.1 R305.1 50.43,121.66 51.31,120.78 R309.1
OSPI_DQS_SOC: length 25.2
  TOP w0.132: U18.L21 v1(38.68,111.66)
  L05_SIG02 w0.102: v1(51.97,119.93) 51.63,119.93 51.46,120.1 51.46,120.43 51.35,120.54 50.99,120.54 50.87,120.42 50.87,119.58 49.59,118.29 42.68,118.29 42.58,118.39 42.58,118.74 42.46,118.86 42.23,118.86 42.13,118.75 42.13,117.97 41.85,117.69 38.61,117.69 38.44,117.52 38.44,117 38.61,116.84 39.04,116.84 39.25,116.63 39.25,112.92 39.37,112.8 39.37,112.03 39,111.66 v1(38.68,111.66)
  BOTTOM w0.14: v1(51.97,119.93) 51.7,120.21 R309.2
OSPI_INTN: length 15.9
  TOP w0.132: U18.K20 v1(37.88,110.86)
  TOP w0.14: R50.1 R49.1 40.01,120.11 v1(39.81,119.91)
  BOTTOM w0.114: 37.48,111.32 37.48,112.3
  BOTTOM w0.14: 37.48,112.3 37.37,112.41 37.37,112.99 37.6,113.22 37.6,114.82 38.31,115.54 38.31,117.76 39.31,118.77 39.31,119.41 v1(39.81,119.91) ; v1(37.88,110.86) 37.88,110.93 37.48,111.32
OSPI_RSTN: length 7.7
  TOP w0.14: U11.4 R46.1 44.27,122.95 44.17,122.84 v1(44.17,122.77) ; U12.A4 v1(47.35,119.4)
  L10_SIG03 w0.102: v1(47.35,119.4) 46.87,119.88 46.87,120.66 46.1,121.43 45.51,121.43 v1(44.17,122.77)
P2_PP_EXT_ENABLE: length 2.6
  BOTTOM w0.14: R449.1 19.69,40.15 20.58,41.04 U90.49
PD_GPIO0: length 2
  BOTTOM w0.14: R416.2 17.53,49.95 18.18,49.3 U90.16
PD_GPIO2: length 4.3
  TOP w0.14: v1(19.3,51.78) 18.92,51.4 TP58.1
  BOTTOM w0.14: U90.18 18.98,49.26 19.3,49.58 v1(19.3,51.78)
PD_HRESET: length 1.8
  BOTTOM w0.14: U90.44 22.58,41.23 22.72,41.09 22.72,40.49 R445.1
PD_I2C_IRQ: length 58.1
  TOP w0.14: R169.1 R167.2 24.39,47.52 24.01,47.91 v1(24.01,48.71) ; v1(50.36,48.49) 51.15,47.71 51.55,47.71 52.14,47.12 52.88,47.12 53.18,47.43 55.7,47.43 58.24,44.88 v1(58.24,40.04)
  L10_SIG03 w0.102: v1(50.36,48.49) 49.98,48.11 49.98,47.78 48.3,46.11 39.35,46.11 38.72,46.74 38.41,46.74 37.92,47.22 37.32,47.22 37.18,47.09 37,47.09 33.09,47.09 32.66,46.65 32.66,44.93 31.2,43.47 30.68,43.47 30.22,43.02 29.95,43.02 29.57,42.64 26.75,42.64 25.65,41.54 24.99,41.54 23.74,42.79 23.74,48.44 v1(24.01,48.71)
  BOTTOM w0.14: U92.23 57.95,41.61 58.51,41.05 58.51,40.31 v1(58.24,40.04)
PD_M_I2C3_IRQ: length 1.9
  BOTTOM w0.14: U90.23 R412.2
PD_M_I2C3_SCL: length 53.4
  TOP w0.14: R161.2 v1(20.18,49.49)
  L10_SIG03 w0.102: v1(65.08,58.48) 64.16,59.4 60.89,59.4 60,58.51 55.6,58.51 53.57,56.48 53.57,54.47 50.5,51.4 45.65,51.4 45.04,50.79 42.27,50.79 41.89,50.41 31.54,50.41 31.05,49.92 25.22,49.92 24.62,49.32 23.55,49.32 23.08,48.85 20.82,48.85 v1(20.18,49.49)
  BOTTOM w0.14: v1(20.18,49.49) U90.21 ; v1(65.08,58.48) 65.37,58.77 R395.1
PD_M_I2C3_SDA: length 55.1
  TOP w0.14: R158.2 v1(20.18,50.4)
  L10_SIG03 w0.102: v1(61.22,58.97) 60.89,58.97 60.16,58.24 55.72,58.24 53.95,56.48 53.95,52.41 52.5,50.97 46.03,50.97 44.94,49.87 42.39,49.87 42.09,50.18 31.64,50.18 31.15,49.69 25.31,49.69 24.71,49.09 23.85,49.09 23.35,48.59 20.3,48.59 19.68,49.21 19.68,49.9 v1(20.18,50.4)
  BOTTOM w0.14: R396.1 62.78,59.2 61.45,59.2 v1(61.22,58.97) ; v1(20.18,50.4) 20.66,49.92 20.66,49.16 20.58,49.08 U90.22
PD_MS_I2C1_IRQ: length 1.5
  BOTTOM w0.14: R419.2 24.64,47.89 24.5,47.76 U90.29
PD_MS_I2C1_SCL: length 50.7
  L10_SIG03 w0.102: v1(23.29,49.7) 23.43,49.7 24.11,50.37 24.91,50.37 25.48,50.94 40.82,50.94 42.6,52.72 45.4,52.72 45.84,52.28 49.08,52.28 50.23,53.43 51.16,53.43 52.94,55.21 52.94,56.55 55.36,58.97 59.49,58.97 61.04,60.52 63.91,60.52 v1(65.08,59.35)
  BOTTOM w0.14: U90.27 22.58,48.99 v1(23.29,49.7) R415.2 ; R393.1 65.27,59.54 v1(65.08,59.35)
PD_MS_I2C1_SDA: length 46.6
  L10_SIG03 w0.102: v1(24.21,49.7) 24.65,50.15 30.95,50.15 31.44,50.64 41.3,50.64 42.42,51.75 49.28,51.75 50.65,53.13 51.23,53.13 53.19,55.08 53.19,56.48 55.45,58.74 59.74,58.74 60.89,59.88 v1(61.22,59.88)
  BOTTOM w0.14: v1(61.22,59.88) 61.93,59.88 62.27,59.54 R394.1 ; U90.28 22.98,48.76 23.41,49.18 23.69,49.18 v1(24.21,49.7) R414.2
PD_S_I2C2_IRQ: length 2.6
  TOP w0.14: R169.2 25.19,46.14 25.33,46 v1(25.33,45.76)
  BOTTOM w0.14: v1(25.33,45.76) 25.21,45.88 24.48,45.88 24.36,45.76 U90.34
PD_S_I2C2_SCL: length 1.7
  BOTTOM w0.14: R421.2 24.79,47.13 24.22,46.56 U90.32
PD_S_I2C2_SDA: length 1.6
  BOTTOM w0.14: U90.33 24.25,46.16 24.46,46.37 R422.2
PD_SPI_CLK: length 50.9
  TOP w0.14: J11.7 58.68,58.18 59.46,58.97 59.46,62.19 59.16,62.49 U34.6
  L10_SIG03 w0.102: v1(26.37,43.85) 25.76,44.46 25.76,46.06 26.52,46.83 28.71,46.83 30.19,48.31 30.62,48.31 32,49.7 41.29,49.7 42.31,48.68 42.31,48.22 42.59,47.94 45.11,47.94 47.68,50.51 54.97,50.51 57.51,53.05 57.51,55.96 J11.7
  BOTTOM w0.14: R436.2 26.15,43.64 v1(26.37,43.85)
PD_SPI_MISO: length 51.6
  TOP w0.14: R146.2 U34.2 62.41,61.22 61.72,60.54 61.72,58.56 61.22,58.05 J11.5
  L10_SIG03 w0.102: J11.5 60.03,55.94 60.03,53.54 56.49,50 50.29,50 48.33,48.04 47.52,48.04 46.06,46.57 41.28,46.57 40.78,47.07 40.78,47.98 40.41,48.35 32.01,48.35 31.29,47.63 31.29,46.87 29.8,45.38 26.49,45.38 v1(26.37,45.51)
  BOTTOM w0.14: v1(26.37,45.51) 26.13,45.51 R426.2
PD_SPI_MOSI: length 53.3
  TOP w0.14: J11.8 59.95,55.85 59.95,63.18 59.37,63.76 U34.5
  L10_SIG03 w0.102: J11.8 58.12,54.02 58.12,52.77 55.63,50.28 50.24,50.28 50.24,50.27 48.29,48.32 47.41,48.32 47.01,47.91 46.19,47.91 45.08,46.81 44.96,46.81 44.96,46.8 41.49,46.8 41.05,47.25 41.05,48.68 40.52,49.21 32.38,49.21 30.87,47.7 30.87,47.24 30.12,46.49 26.68,46.49 25.99,45.8 25.99,45.07 v1(26.37,44.69)
  BOTTOM w0.14: v1(26.37,44.69) 26.07,44.4 R431.2
PD_SPI_SS: length 62.8
  TOP w0.14: J11.9 56.89,57.12 57.36,56.66 57.36,53.94 57.89,53.4 61.93,53.4 62.51,53.99 62.51,58.03 62.05,58.48 62.05,59.53 62.48,59.95 U34.1 R147.2
  L10_SIG03 w0.102: v1(25.23,42.02) 24.03,43.22 24.03,45.38 25.86,47.21 28.68,47.21 30.08,48.61 30.59,48.61 31.9,49.92 41.56,49.92 42.57,48.91 44.99,48.91 46.81,50.74 52.78,50.74 54.94,52.9 54.94,55.93 J11.9
  BOTTOM w0.14: R439.2 25.01,42.24 v1(25.23,42.02)
PD_VIN_3V3: length 1.8
  TOP w0.381: C123.2 15.81,44.58 16.04,44.35 v1(16.11,44.35)
  BOTTOM w0.14: v1(16.11,44.35) 16.3,44.16 U90.5
PMIC_AMUXOUT: length 2
  TOP w0.14: U27.1 21.5,76.54 22.29,75.75 TP36.1
PMIC_ENABLE: length 26.6
  TOP w0.14: TP42.1 11.86,66.32 v1(11.86,66.31) 11.01,65.46 7.16,65.46 5.32,67.3 4.78,67.3 3.66,68.42 U31.4 ; U36.1 v1(17.93,56.75)
  L05_SIG02 w0.102: v1(11.86,66.31) 11.86,61.08 16.19,56.75 v1(17.93,56.75)
PMIC_ENABLE_SEL: length 7.3
  TOP w0.14: U31.1 2.16,68.69 1.51,68.04 R138.1 1.91,67.61 2.19,67.33 2.19,64.58 2.54,64.23 J9.1
PMIC_INT_B: length 8.8
  TOP w0.14: R127.2 27.3,81.75 27.13,81.92 27.13,81.93 27.14,81.94 27.14,82.65 27,82.79 R126.1 26.34,83.16 R123.2 TP33.1 24.85,84.08 22.55,84.08 21.52,83.04 U27.14
PMIC_INTN: length 46
  TOP w0.132: U18.F17 v1(34.68,108.46)
  TOP w0.14: R53.2 33.96,115.73 v1(34.41,115.29) ; R127.1 27.74,80.77 v1(28.03,80.48)
  L10_SIG03 w0.102: v1(28.03,80.48) 28.03,81.63 28.13,81.73 28.13,82.52 27.2,83.45 27.2,94.8 30.06,97.67 32.45,97.67 32.68,97.9 32.68,98.23 32.91,98.47 33.25,98.47 34.28,99.5 34.28,99.83 34.51,100.07 34.78,100.07 34.85,100.07 35.08,100.3 U18.F17 v1(34.68,108.46) 35.08,108.86 35.65,108.86 35.88,109.1 35.88,110.23 35.89,110.24 36.11,110.47 36.45,110.47 36.68,110.7 36.68,111.83 36.3,112.21 36.3,113.4 v1(34.41,115.29)
PMIC_LPM_EN0: length 83.3
  TOP w0.132: U18.D12 v1(33.08,104.46)
  TOP w0.14: U31.8 3.16,75.29 3.61,75.74 4.69,75.74 v1(4.93,75.99) ; U31.3 3.16,68.18 3.85,67.48 v1(3.85,66.78) 5.1,66.78 6.37,65.51 R140.1 12.59,65.11 13.73,66.26 16.75,66.26 v1(17.72,67.23) 18.01,67.52 TP41.1
  L05_SIG02 w0.102: v1(4.93,75.99) 4.04,75.09 4.04,70.78 3.91,70.65 3.91,66.84 v1(3.85,66.78)
  L10_SIG03 w0.102: v1(33.08,104.46) 33.08,103.93 33.09,103.93 32.64,103.48 31.05,103.48 30.75,103.18 28.93,103.18 28.71,103.4 27.84,103.4 26.34,101.91 24.13,101.91 22.9,100.67 22.32,100.67 21.92,100.27 20.27,100.27 19.6,99.6 19.04,99.6 18.76,99.32 18.76,95.44 18.49,95.17 18.49,88.39 18.51,88.37 18.51,88.05 18.51,87.86 18.49,87.85 18.49,87.62 18.51,87.61 18.51,87.1 18.49,87.08 18.49,85.51 19.24,84.76 19.24,82.82 18.95,82.53 18.95,76.04 19.17,75.82 19.17,74.63 18.56,74.02 18.56,68.76 17.72,67.93 v1(17.72,67.23)
PMIC_NPWRON/ENABLE: length 29.7
  TOP w0.132: v1(17.74,83.17) U27.20
  TOP w0.14: R148.2 21.67,58.9 v1(20.41,60.16)
  L03_SIG01 w0.102: v1(17.74,83.17) 17.57,83.17 17.01,82.6 17.01,75.65 17.62,75.04 17.62,74.07 18.81,72.88 18.81,71.14 19.85,70.11 19.85,66.64 20.9,65.59 20.9,60.65 v1(20.41,60.16)
PMIC_NSLEEP: length 13.5
  TOP w0.14: v1(4.93,75.04) 4.34,75.04 4.16,74.86 U31.6 ; U27.46 15.24,74.99 v1(15.31,74.91)
  BOTTOM w0.14: v1(4.93,75.04) 5.25,75.36 11.14,75.36 11.58,74.91 v1(15.31,74.91)
PMIC_OSC32KCAP: length 1.4
  TOP w0.305: U27.40 v1(12.16,77.54)
  BOTTOM w0.305: v1(12.16,77.54) 12.16,77.32 C381.1
PMIC_OSC32KIN: length 8.7
  TOP w0.132: 10.51,77.08 9.92,76.49 7.75,76.49 7.48,76.76 Y3.2 ; 10.51,77.08 C85.2 ; 10.51,77.08 10.51,76.62 10.64,76.49 10.88,76.49 11.12,76.73 11.12,77.94 11.72,78.54 U27.38
PMIC_OSC32KOUT: length 8.7
  TOP w0.132: Y3.1 7.48,75.73 7.86,76.11 9.92,76.11 10.51,75.52 ; 10.51,75.52 C89.2 ; 10.51,75.52 10.51,75.97 10.64,76.11 11.03,76.11 11.53,76.6 11.53,77.78 11.79,78.04 U27.39
PMIC_POWERGOOD: length 98.6
  TOP w0.132: v1(15.24,83.17) U27.25
  TOP w0.14: TP81.1 v1(22.96,23.92)
  L03_SIG01 w0.102: v1(22.96,23.92) 22.96,24.47 22.45,24.99 22.45,33.29 21.04,34.7 21.04,37.08 18.14,39.98 18.14,40.36 17.59,40.9 17.59,49.68 15.61,51.66 15.61,55.58 10.97,60.23 10.97,66.87 12.76,68.66 12.76,73.39 10.31,75.83 10.31,75.84 10.12,76.03 10.12,76.59 10.12,80.88 10.12,83.33 12.05,85.26 v1(12.05,87.95)
  L05_SIG02 w0.102: v1(33.9,15.68) 33.08,14.86 30.72,14.86 27.14,18.44 25.37,18.44 23.32,20.49 23.32,23.56 v1(22.96,23.92)
  BOTTOM w0.14: R500.1 R501.1 23.37,24.32 v1(22.96,23.92) ; v1(15.24,83.17) 12.05,86.36 v1(12.05,87.95) ; U116.1 33.72,15.89 33.9,15.7 v1(33.9,15.68)
PMIC_WDOG_DISABLE: length 92.6
  TOP w0.14: v1(61.04,26.69) 61.04,28.28 60.4,28.93 60.4,30.05 TP74.1 ; v1(10.67,74.65) 11.07,74.65 11.32,74.9 11.32,75.8 12.06,76.55 12.06,76.87 12.23,77.04 U27.41
  L05_SIG02 w0.102: v1(61.04,26.69) 61.04,27.94 60.55,28.43 60.55,29.74 58.4,31.89 56.26,31.89 55.52,32.63 55.17,32.63 53.75,34.04 50.33,34.04 49.77,34.6 47.54,34.6 46.11,36.03 46.11,36.6 42.33,40.38 42,40.38 41.73,40.65 41.73,43.34 32.37,52.69 29.16,52.69 28.43,53.42 23.46,53.42 22.48,54.4 20.89,54.4 20.56,54.73 17.52,54.73 10.91,61.33 10.91,67.58 10.67,67.82 10.67,74.6 10.67,74.6 v1(10.67,74.65)
  BOTTOM w0.14: v1(61.04,26.69) 62.01,26.69 62.66,26.04 R492.1 R493.2
PMIC_WDOG_TRIGG: length 52.5
  TOP w0.132: U18.D13 v1(33.08,105.26)
  TOP w0.14: v1(20.26,67.86) 20.26,67.67 R137.1
  L05_SIG02 w0.102: v1(20.26,67.86) 20.26,70.69 20.75,71.18 20.75,74.11 20.14,74.72 20.14,85.74 18.82,87.06 18.82,88.54 18.5,88.86 18.5,90.79 18.74,91.02 18.74,100.31 20.1,101.67 20.1,102.8 20.81,103.52 21.54,103.52 22.67,104.65 29.04,104.65 29.34,104.95 30.34,104.95 30.44,104.86 30.84,104.86 31.08,105.1 31.08,105.43 31.31,105.66 32.68,105.66 v1(33.08,105.26)
PORZ_OUT: length 188.2
  TOP w0.132: U18.F18 v1(34.68,109.26)
  TOP w0.14: v1(3.97,92.21) 3.97,92.7 R104.1 4.91,92.89 4.91,92.66 5.17,92.4 U24.6 ; TP63.1 v1(58.47,46.24) R170.2 ; v1(62.98,41.49) 62.98,42.06 63.17,42.25 U41.3 ; v1(61.46,37.55) 62.69,38.77 U42.3
  L03_SIG01 w0.102: v1(5.63,59.92) 7.43,59.92 8.47,58.89 11.15,58.89 14.79,55.25 14.79,41.37 15.63,40.53 17.18,40.53 v1(17.64,40.07)
  L05_SIG02 w0.102: v1(58.47,46.24) 56.75,44.51 56.75,41.85 57.13,41.47 58.2,41.47 59.86,39.81 60.72,39.81 60.95,40.04 61.89,40.04 62.3,40.44 62.3,40.81 v1(62.98,41.49) 63.71,40.76 63.71,37.94 62.93,37.17 61.84,37.17 v1(61.46,37.55)
  L10_SIG03 w0.102: v1(3.97,92.21) 4.26,91.92 4.26,89.61 4.57,89.3 4.57,87.92 8.16,84.33 8.16,80.91 7.67,80.43 7.67,73.13 3.38,68.84 3.38,65.14 3.75,64.76 3.75,60.82 4.65,59.92 v1(5.63,59.92) ; v1(17.64,40.07) 18.09,39.61 19.28,39.61 19.51,39.84 21.76,39.84 22.36,39.24 24.98,39.24 25.54,39.81 26.14,39.81 26.32,39.63 29.54,39.63 30.27,38.9 35.58,38.9 36.06,39.38 36.06,41.22 38.77,43.94 46.02,43.94 46.61,43.34 47.08,43.34 47.82,42.61 50.35,42.61 53.16,45.42 57.66,45.42 v1(58.47,46.24) ; v1(34.68,109.26) 34.6,109.26 34.2,109.66 33.71,109.66 33.48,109.9 33.48,110.3 33.32,110.47 32.9,110.47 32.68,110.68 32.68,111.1 32.51,111.26 31.12,111.26 31.12,111.26 30.47,110.61 26.29,110.61 25.12,109.44 24.31,109.44 24.09,109.65 22.75,109.65 v1(20.86,107.76)
  BOTTOM w0.14: v1(3.97,92.21) 4.33,91.86 8.84,91.86 10.95,93.97 10.95,96.05 11.56,96.66 11.56,101.72 14.02,104.18 20.45,104.18 21.8,105.53 21.8,106.82 v1(20.86,107.76)
PP1_CABLE: length 1.6
  TOP w0.14: C117.1 v1(21.78,49.32)
  BOTTOM w0.14: v1(21.78,49.32) U90.25
PP2_CABLE: length 1.9
  BOTTOM w0.14: U90.46 21.78,40.81 R447.2
PR0_PRU0_GPO0: length 121.3
  TOP w0.132: U18.N21 v1(41.08,111.66)
  L10_SIG03 w0.102: v1(41.08,111.66) 40.68,112.06 39.91,112.06 39.69,111.84 39.69,110.49 39.39,110.19 39.39,100.58 39.91,100.07 44.5,100.07 44.68,99.89 44.68,99.5 44.91,99.26 45.25,99.26 45.48,99.03 45.48,98.7 45.71,98.47 46.05,98.47 46.28,98.23 46.28,97.9 46.51,97.67 46.8,97.67 46.8,97.67 46.85,97.67 47.08,97.43 47.08,97.1 47.31,96.87 47.32,96.86 47.65,96.86 47.88,96.63 47.88,96.3 48.11,96.07 49.09,96.07 51.51,93.64 51.51,91.78 49.54,89.81 49.54,83.6 50.95,82.19 50.95,73.96 55.4,69.52 55.4,68.35 59.52,64.22 64.24,64.22 66.09,62.37 66.09,58.86 64.87,57.65 64.87,57.64 64.87,54.01 63.38,52.52 63.38,51.83 62.92,51.37 62.92,45.1 61.45,43.63 61.45,41.16 61.71,40.9 61.71,40.15 61.21,39.65 60.35,39.65 59.32,38.61 58.18,38.61 57.64,38.06 54.15,38.06 53.5,38.71 51.66,38.71 50.72,39.65 48.63,39.65 47.69,38.71 45.94,38.71 44.58,40.07 41.08,40.07 40.84,39.82 40.84,38.64 v1(41.17,38.31)
  BOTTOM w0.14: v1(41.17,38.31) 41.03,38.45 RA5.8
PR0_PRU0_GPO1: length 117
  TOP w0.132: U18.N20 v1(41.08,110.86)
  L10_SIG03 w0.102: v1(41.08,110.86) U18.N20 40.06,110.47 39.63,110.03 39.63,101.31 40.07,100.86 44.45,100.86 44.68,100.63 44.68,100.34 44.68,100.3 44.91,100.07 45.25,100.07 45.48,99.83 45.48,99.5 45.71,99.27 46,99.27 46,99.26 46.05,99.26 46.28,99.03 46.28,98.64 46.46,98.47 46.85,98.47 47.08,98.23 47.08,98.22 47.08,97.9 47.31,97.67 47.65,97.67 47.88,97.43 47.88,97.1 48.11,96.87 48.64,96.87 51.74,93.77 51.74,91.66 49.77,89.69 49.77,83.72 51.18,82.31 51.18,74.05 55.62,69.61 55.62,68.44 59.61,64.45 64.33,64.45 66.32,62.47 66.32,58.76 65.1,57.54 65.1,52.69 63.17,50.76 63.17,44.95 62.31,44.08 62.31,39.44 61.77,38.89 61.34,38.89 60.76,38.31 58.27,38.31 57.61,37.66 54.23,37.66 53.41,38.48 51.29,38.48 50.98,38.78 48.24,38.78 47.92,38.46 43.04,38.46 v1(42.65,38.85)
  BOTTOM w0.14: RA5.7 v1(42.65,38.85)
PR0_PRU0_GPO2: length 119.3
  TOP w0.132: U18.N19 v1(41.08,110.06)
  L10_SIG03 w0.102: v1(42.15,39.65) 42.15,38.67 42.69,38.14 46.51,38.14 47.57,37.08 50.56,37.08 50.87,37.39 51.9,37.39 52.28,37.01 54.47,37.01 54.73,36.74 55.21,36.74 55.71,37.25 57.71,37.25 58.39,37.93 61.49,37.93 62.54,38.98 62.54,41.9 63.43,42.79 63.43,50.64 66.02,53.23 66.67,53.23 67.41,53.96 67.41,61.7 64.43,64.68 59.82,64.68 55.85,68.65 55.85,69.71 51.41,74.15 51.41,82.44 50,83.85 50,89.53 52,91.53 52,94.11 48.45,97.67 48.11,97.67 47.88,97.9 47.88,98.23 47.65,98.47 47.31,98.47 47.08,98.7 47.08,99.03 46.85,99.26 46.56,99.26 46.56,99.27 46.51,99.27 46.28,99.5 46.28,99.54 46.28,99.83 46.05,100.07 45.7,100.07 45.48,100.28 45.48,100.63 45.25,100.86 44.91,100.86 44.68,101.1 44.68,101.43 44.45,101.67 40.06,101.67 39.87,101.85 39.87,109.45 40.09,109.66 40.74,109.66 41.08,110 v1(41.08,110.06)
  BOTTOM w0.14: RA5.6 41.75,39.25 v1(42.15,39.65)
PR0_PRU0_GPO3: length 117.7
  TOP w0.132: U18.N18 v1(41.08,109.26)
  L10_SIG03 w0.102: v1(41.24,39.65) 41.24,39.14 43.56,36.82 50.75,36.82 51.68,35.9 55.04,35.9 55.51,36.38 56.09,36.38 56.66,36.95 61.45,36.95 61.87,37.37 61.87,37.8 62.77,38.7 62.77,40.66 63.38,41.26 63.38,42.38 63.68,42.69 63.68,50.56 66.07,52.95 66.75,52.95 67.64,53.84 67.64,61.8 64.52,64.91 59.98,64.91 56.08,68.8 56.08,69.8 51.67,74.22 51.67,82.59 50.23,84.03 50.23,89.31 52.25,91.33 52.25,94.66 48.42,98.49 48.14,98.49 47.91,98.71 47.91,99.04 47.69,99.26 47.31,99.26 47.08,99.5 47.08,99.79 47.08,99.83 46.85,100.07 46.8,100.07 46.51,100.07 46.28,100.3 46.28,100.63 46.05,100.86 45.71,100.86 45.48,101.1 45.48,101.43 45.25,101.67 45.2,101.67 44.91,101.67 44.68,101.9 44.68,102.23 44.45,102.47 40.91,102.47 40.68,102.7 U18.N18 v1(41.08,109.26)
  BOTTOM w0.14: RA5.5 v1(41.24,39.65)
PR0_PRU0_GPO4: length 125.2
  TOP w0.132: U18.N17 v1(41.08,108.46)
  L10_SIG03 w0.102: v1(31.5,33.86) 32.82,35.18 58.36,35.18 59.2,36.02 61.41,36.02 63.76,38.37 63.76,40.96 64.24,41.44 64.24,45.35 66.04,47.16 66.04,51.14 67.87,52.97 67.87,61.89 64.62,65.14 60.07,65.14 56.31,68.9 56.31,69.9 51.93,74.27 51.93,82.73 50.48,84.18 50.48,89.1 52.5,91.12 52.5,94.92 47.91,99.51 47.91,99.8 47.65,100.07 47.3,100.07 47.08,100.28 47.08,100.71 46.93,100.86 46.55,100.86 46.55,100.87 46.51,100.87 46.28,101.1 46.28,101.41 46.28,101.43 46.05,101.67 45.65,101.67 45.48,101.83 45.48,102.31 45.33,102.47 44.91,102.47 44.68,102.7 44.68,103.03 44.42,103.29 42.09,103.29 41.48,103.9 41.48,107.83 41.25,108.06 41.25,108.29 v1(41.08,108.46)
  BOTTOM w0.14: v1(31.5,33.86) 31.78,33.58 RA6.5
PR0_PRU0_GPO5: length 126
  TOP w0.132: U18.P18 v1(41.88,109.26)
  L10_SIG03 w0.102: v1(32.34,33.89) 33.37,34.91 58.65,34.91 58.87,35.13 60.88,35.13 64.06,38.32 64.06,40.83 64.49,41.26 64.49,45.2 66.3,47 66.3,51.07 68.15,52.92 68.15,54.04 68.73,54.62 68.73,61.38 64.75,65.37 60.3,65.37 57.89,67.78 57.89,68.64 52.2,74.33 52.2,82.81 50.73,84.29 50.73,88.99 52.75,91.02 52.75,95.17 48.24,99.69 48.24,99.98 47.88,100.34 47.88,100.63 47.65,100.86 47.64,100.87 47.31,100.87 47.08,101.1 47.08,101.55 46.97,101.67 46.51,101.67 46.28,101.9 46.28,102.35 46.17,102.47 45.71,102.47 45.48,102.7 45.48,103.05 45.01,103.52 42.73,103.52 42.28,103.96 42.28,107.9 42.12,108.07 41.71,108.07 41.48,108.3 U18.P18 v1(41.88,109.26)
  BOTTOM w0.14: v1(32.34,33.89) 32.18,33.73 RA6.6
PR0_PRU0_GPO6: length 125.3
  TOP w0.132: U18.P19 v1(41.88,110.07)
  L10_SIG03 w0.102: v1(33.53,33.8) 34.42,34.68 58.9,34.68 59.07,34.85 61.03,34.85 64.38,38.21 64.38,39.7 66.58,41.89 66.58,50.99 68.43,52.85 68.43,53.91 68.99,54.47 68.99,61.45 64.84,65.6 60.43,65.6 58.17,67.86 58.17,68.69 52.43,74.43 52.43,82.91 50.96,84.38 50.96,88.9 52.98,90.93 52.98,95.32 48.54,99.76 48.54,100.39 47.88,101.05 47.88,101.51 47.73,101.67 47.31,101.67 47.08,101.9 47.08,102.23 46.85,102.47 46.51,102.47 46.28,102.7 46.28,103.03 45.99,103.32 45.6,103.32 44.68,104.25 44.68,104.63 44.45,104.86 44.08,104.86 43.88,105.07 43.88,105.45 43.66,105.66 43.3,105.66 43.08,105.89 43.08,107.83 42.85,108.06 42.51,108.06 42.28,108.3 42.28,109.48 42.04,109.72 42.04,109.91 v1(41.88,110.07)
  BOTTOM w0.14: v1(33.53,33.8) 33.25,33.52 32.72,33.52 32.58,33.38 RA6.7
