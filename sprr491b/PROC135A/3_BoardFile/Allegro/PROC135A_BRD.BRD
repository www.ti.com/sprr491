# Allegro board PROC135A_BRD.BRD (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CSI0_RXN2: length 54
  TOP w0.089: U18.AA13 v1(47.48,105.26) ; U8.13 71.33,131.51 71.19,131.38 71.19,130.65 70.58,130.03 70.58,129.28 70.75,129.11 70.92,129.11 v1(71.16,129.35)
  L10_SIG03 w0.089: v1(71.16,129.35) 71.16,129.12 71.08,129.03 70.69,129.03 70.39,128.73 70.39,126.89 68.8,125.3 66.54,125.3 64.1,122.86 64.1,122.08 63.97,121.95 62.2,121.95 61.94,121.69 61.94,121.33 62.2,121.07 63.97,121.07 64.1,120.94 64.1,115.32 62.93,114.15 61.38,114.15 60.51,113.28 60.51,111.78 60.04,111.31 60.04,110.22 60.3,109.96 60.84,109.96 60.97,109.83 60.97,109.65 60.84,109.52 60.3,109.52 60.04,109.26 60.04,107.37 56.24,103.58 48.83,103.58 48.14,104.27 48.14,104.66 47.91,104.9 47.57,104.9 47.48,104.99 v1(47.48,105.26)
CSI0_RXN3: length 54.1
  TOP w0.089: v1(72.61,128.04) 72.85,128.28 73.12,128.28 73.35,128.52 73.35,129.92 72.19,131.08 72.19,131.38 72.33,131.51 U8.15 ; U18.AB11 48.17,102.98 49.6,102.98 49.82,102.76 49.82,102.35 v1(50.1,102.07)
  L10_SIG03 w0.089: v1(72.61,128.04) 72.61,128.18 72.77,128.34 73.08,128.34 73.23,128.19 73.23,126.68 69.94,123.4 68.85,123.4 67.75,122.29 67.75,111.38 67.18,110.81 66.14,110.81 65.89,110.55 65.89,110.19 66.13,109.94 66.13,109.76 66,109.63 65.82,109.63 65.57,109.87 65.21,109.87 64.95,109.62 64.95,109.25 65.2,109.01 65.2,108.82 65.07,108.69 64.88,108.69 64.64,108.94 64.27,108.94 64.02,108.68 64.02,108.32 64.26,108.07 64.26,107.89 58.01,101.64 49.89,101.64 49.78,101.74 49.78,101.92 49.93,102.07 v1(50.1,102.07)
CSI0_RXP0: length 54
  TOP w0.089: U18.W13 v1(45.88,105.26) ; U8.7 68.33,131.61 68.46,131.48 68.46,130.92 v1(68.22,130.68)
  L10_SIG03 w0.089: v1(68.22,130.68) 68.45,130.44 68.45,130.2 68.68,129.97 70.5,129.97 71.09,130.56 71.62,130.56 71.86,130.32 71.86,126.83 69.39,124.36 67.76,124.36 66.05,122.65 66.05,114.88 65.35,114.18 65.35,111.72 62.6,108.97 62.6,108.07 57.26,102.73 48.45,102.73 47.26,103.92 46.5,103.92 46.29,104.13 46.29,104.86 v1(45.88,105.26)
CSI0_RXP1: length 54
  TOP w0.089: v1(68.75,129.35) 68.99,129.59 68.99,129.98 69.96,130.95 69.96,131.38 69.83,131.51 U8.10 ; U18.Y14 v1(46.68,106.06)
  L10_SIG03 w0.089: v1(68.75,129.35) 69,129.1 69,127.38 67.86,126.24 65.07,126.24 63.47,124.64 62.17,124.64 61.91,124.39 61.91,123.87 61.77,123.73 61.61,123.73 61.47,123.87 61.47,124.39 61.21,124.64 59.63,124.64 58.91,123.92 58.91,122.75 59.1,122.56 59.1,121.11 59.36,120.86 60.33,120.86 60.43,120.75 60.43,120.57 60.28,120.41 59.49,120.41 59.28,120.2 59.28,114.05 58.36,113.14 58.36,110.77 58.58,110.56 58.58,109.21 58.45,109.08 57.55,109.08 57.3,108.83 57.3,108.46 57.55,108.21 58.45,108.21 58.58,108.08 58.58,107.78 55.36,104.57 49.39,104.57 48.08,105.88 47.2,105.88 47,105.68 46.69,105.68 46.61,105.77 46.61,105.99 v1(46.68,106.06)
CSI0_RXP2: length 54
  TOP w0.089: v1(71.16,128.64) 70.92,128.88 70.65,128.88 70.35,129.18 70.35,130.13 70.96,130.74 70.96,131.38 70.83,131.51 U8.12 ; U18.AA12 v1(47.48,104.46)
  L10_SIG03 w0.089: v1(71.16,128.64) 70.99,128.81 70.78,128.81 70.6,128.64 70.6,126.8 68.89,125.09 66.63,125.09 64.32,122.78 64.32,121.99 64.06,121.73 62.29,121.73 62.16,121.6 62.16,121.42 62.29,121.29 64.06,121.29 64.32,121.03 64.32,115.23 63.02,113.94 61.47,113.94 60.72,113.19 60.72,111.69 60.25,111.22 60.25,110.31 60.38,110.18 60.92,110.18 61.18,109.92 61.18,109.56 60.92,109.3 60.38,109.3 60.25,109.17 60.25,107.29 56.33,103.36 48.74,103.36 47.93,104.18 47.93,104.57 47.82,104.68 47.62,104.68 47.48,104.54 v1(47.48,104.46)
CSI0_RXP3: length 54.1
  TOP w0.089: v1(49.39,102.07) 49.59,102.26 49.59,102.67 49.5,102.75 48.17,102.75 U18.AB10 ; U8.14 71.83,131.51 71.96,131.38 71.96,130.98 73.13,129.82 73.13,128.61 73.02,128.51 72.85,128.51 v1(72.61,128.75)
  L10_SIG03 w0.089: v1(49.39,102.07) 49.57,101.89 49.57,101.66 49.8,101.42 58.1,101.42 64.48,107.8 64.48,108.16 64.23,108.41 64.23,108.59 64.36,108.72 64.55,108.72 64.79,108.48 65.15,108.48 65.41,108.73 65.41,109.1 65.17,109.34 65.17,109.53 65.3,109.66 65.48,109.66 65.73,109.41 66.09,109.41 66.35,109.67 66.35,110.03 66.1,110.28 66.1,110.46 66.23,110.59 67.27,110.59 67.96,111.29 67.96,122.2 68.94,123.18 70.03,123.18 73.44,126.59 73.44,128.28 73.17,128.56 72.8,128.56 v1(72.61,128.75)
CSI0_RXRCALIB: length 6.1
  TOP w0.132: U18.V10 v1(45.08,102.07)
  BOTTOM w0.14: R328.2 48.79,103.65 45.95,103.65 45.48,103.17 45.48,102.47 v1(45.08,102.07)
CSI_EN: length 30.8
  TOP w0.14: v1(66,130.88) 66,131.38 65.83,131.56 U8.2 ; U2.21 v1(53.61,150.06)
  BOTTOM w0.14: R292.2 65.94,130.82 v1(66,130.88) 66,131.09 66.51,131.59 66.51,133.08 66.2,133.4 65.35,133.4 62.57,136.18 61.84,136.18 60.92,137.1 60.92,139.41 58.8,141.53 56.8,141.53 55.81,142.52 55.81,145.22 56.1,145.51 56.1,148.93 55.61,149.42 54.74,149.42 54.56,149.6 54.07,149.6 v1(53.61,150.06)
CSI_GPIO0: length 140.2
  TOP w0.14: v1(57.12,140.04) 57.12,140.53 56.78,140.87 U4.20
  L05_SIG02 w0.102: v1(57.12,140.04) 57.12,134.36 59.39,132.09 59.39,128.11 60.95,126.55 64.69,126.55 66.22,125.01 66.22,115.94 65.55,115.27 65.55,109.8 66.53,108.83 66.53,105.07 65.89,104.43 65.89,101.69 64.7,100.5 64.7,93.25 65.48,92.47 65.48,89.58 65.85,89.21 66.13,89.21 66.43,88.9 66.43,73.86 65.44,72.87 65.44,67.7 66.17,66.96 66.17,58.87 65.15,57.85 65.15,53.33 v1(63.83,52.01)
  L10_SIG03 w0.102: v1(71,152.19) 71.43,152.19 72.54,151.07 72.54,150.23 70.56,148.24 68.98,148.24 68.02,147.27 68.02,146.16 61.89,140.04 v1(57.12,140.04)
  BOTTOM w0.14: U92.14 55.2,46.31 59.98,51.09 62.92,51.09 v1(63.83,52.01) ; J20.17 74.08,150.73 73.55,151.26 71.93,151.26 v1(71,152.19)
CSI_GPIO1: length 144.1
  TOP w0.14: U4.18 54.96,138.87 55.41,138.42 58.7,138.42 v1(58.91,138.62)
  L05_SIG02 w0.102: v1(55.94,46.29) 55.98,46.29 56.42,46.72 58.88,46.72 60.56,45.05 61.49,45.05 61.7,45.25 64.16,45.25 66.09,47.18 66.09,50.34 67.8,52.04 67.8,63.43 68.29,63.93 68.29,77.35 66.9,78.74 66.9,90.12 65.94,91.07 65.94,98.37 66.7,99.12 66.7,102.02 67.34,102.65 67.34,103.11 67.06,103.39 67.06,105.63 68.19,106.76 68.19,109.71 67.38,110.52 67.38,119.19 66.68,119.89 66.68,125.67 66.46,125.89 66.46,128.6 66.39,128.67 66.39,131.16 62.89,134.66 62.89,136.77 61.04,138.62 v1(58.91,138.62)
  L10_SIG03 w0.102: v1(58.91,138.62) 60.8,138.62 68.49,146.31 68.49,147.29 69.12,147.92 70.89,147.92 72.85,149.87 72.85,151.58 v1(72.27,152.16)
  BOTTOM w0.14: v1(55.94,46.29) 55.7,46.05 U92.15 ; J20.18 74.58,150.95 73.86,151.66 72.77,151.66 v1(72.27,152.16)
CSI_GPIO2: length 4.4
  TOP w0.14: U4.17 v1(54.46,139.03)
  BOTTOM w0.14: U55.6 52.97,137.74 53.17,137.54 53.69,137.54 53.98,137.82 53.98,138.55 v1(54.46,139.03)
CSI_GPIO3: length 5.9
  TOP w0.14: U4.16 53.96,138.51 v1(54.46,138.01)
  BOTTOM w0.14: v1(54.46,138.01) 54.46,137.29 52.96,135.79 U55.3
CSI_GPIO4: length 6.1
  TOP w0.14: U4.15 v1(53.46,139.03)
  BOTTOM w0.14: v1(53.46,139.03) 53.96,139.53 54.85,139.53 55,139.37 55,138.64 55.26,138.39 U55.10
CSI_I2C2_NINT1: length 2
  TOP w0.14: R29.2 40.71,137.66 40.82,137.77 U5.8
CSI_I2C2_SCL: length 67.8
  TOP w0.14: U3.8 v1(55.37,150.21) ; R31.2 42.24,137.35 v1(42.12,137.47) U5.10
  L05_SIG02 w0.102: v1(55.37,150.21) 55.79,150.21 56.47,150.89 59.49,150.89 59.9,150.48 64.57,150.48 64.98,150.08 71.49,150.08 v1(74.32,147.25)
  L10_SIG03 w0.102: v1(55.37,150.21) 55.9,149.68 55.9,148.39 55.21,147.7 47.06,147.7 46.8,147.96 45.71,147.96 45.51,147.76 41.29,147.76 41.01,147.48 41.01,145.31 41.45,144.87 49.38,144.87 50.31,143.94 50.31,141.49 48.16,139.34 43.99,139.34 v1(42.12,137.47)
  BOTTOM w0.14: v1(74.32,147.25) 75.58,148.5 J20.20
CSI_I2C2_SDA: length 68.9
  TOP w0.14: U3.1 v1(55.37,148.73) ; R30.2 41.47,137.31 v1(41.3,137.48) 41.47,137.64 U5.9
  L05_SIG02 w0.102: v1(75.21,147.24) 74.77,146.8 73.82,146.8 70.77,149.85 64.8,149.85 64.39,150.25 57.89,150.25 57.25,149.62 56.26,149.62 v1(55.37,148.73)
  L10_SIG03 w0.102: v1(55.37,148.73) 55.32,148.68 45,148.68 44.6,149.08 41.6,149.08 40.62,148.1 40.62,146.76 40,146.14 40,145.03 41.01,144.03 49.49,144.03 50.03,143.48 50.03,141.56 48.04,139.57 43.66,139.57 41.85,137.76 41.58,137.76 v1(41.3,137.48)
  BOTTOM w0.14: J20.21 76.08,148.11 v1(75.21,147.24)
CSI_I2C_LT_EN: length 2.2
  TOP w0.14: U3.6 56.37,152.02 R4.1 R5.2
CSI_MIPI_GPIO0: length 26.9
  TOP w0.14: v1(56.51,143.1) 56.51,142.67 56.22,142.37 U4.1 ; J1.6 v1(65.58,150.93)
  L10_SIG03 w0.102: v1(56.51,143.1) 53.13,143.1 51.82,144.42 51.82,146.42 52.5,147.1 52.63,147.23 57.7,147.23 58.34,146.6 62.08,146.6 65.58,150.1 v1(65.58,150.93)
CSI_MIPI_GPIO1: length 28.1
  TOP w0.14: J1.8 66.08,151.54 v1(65.66,151.95) ; U4.3 v1(54.96,144.2)
  L10_SIG03 w0.102: v1(54.96,144.2) 54.23,143.47 53.13,143.47 52.12,144.48 52.12,146.4 52.73,147 57.61,147 58.28,146.34 60.64,146.34 61.24,145.73 61.88,145.73 66.04,149.9 66.04,151.57 v1(65.66,151.95)
CSI_MIPI_GPIO2: length 25.7
  TOP w0.14: J1.18 v1(70.08,152.21) ; U4.4 54.46,144.72 v1(53.96,145.22)
  L10_SIG03 w0.102: v1(53.96,145.22) 54.37,145.63 59.34,145.63 60.05,144.92 62.18,144.92 66.72,149.47 68.66,149.47 70.08,150.88 v1(70.08,152.21)
CSI_MIPI_GPIO3: length 23.3
  TOP w0.14: U4.5 v1(53.96,144.2) ; J1.20 v1(70.58,151.26)
  L10_SIG03 w0.102: v1(70.58,151.26) 70.58,150.48 69.23,149.13 66.79,149.13 62.25,144.59 59.95,144.59 59.71,144.84 54.59,144.84 v1(53.96,144.2)
CSI_MIPI_GPIO4: length 32.7
  TOP w0.14: U4.6 53.46,144.72 v1(52.96,145.22) ; v1(71.58,152.86) J1.22
  L10_SIG03 w0.102: v1(52.96,145.22) 52.97,145.22 53.39,144.79 53.39,144.06 53.67,143.78 54.16,143.78 54.38,144 54.38,144.19 54.78,144.59 59.53,144.59 60.35,143.78 61.88,143.78 66.79,148.69 69.9,148.69 71.51,150.3 71.51,150.86 70.59,151.78 70.59,152.52 70.93,152.86 v1(71.58,152.86)
CSI_MIPI_I2C2_SCL: length 19.3
  TOP w0.14: v1(63.37,153.24) 64.08,152.53 J1.2 ; U3.5 v1(56.87,150.23)
  L10_SIG03 w0.102: v1(56.87,150.23) 56.87,149.34 59.11,147.1 61.49,147.1 63.46,149.07 63.46,153.15 v1(63.37,153.24)
  BOTTOM w0.14: R246.2 v1(56.87,150.23)
CSI_MIPI_I2C2_SDA: length 18.8
  TOP w0.14: U3.4 v1(56.87,148.75) ; J1.4 v1(64.58,153.24)
  L10_SIG03 w0.102: v1(64.58,153.24) 64.58,149.72 61.73,146.88 58.75,146.88 v1(56.87,148.75)
  BOTTOM w0.14: v1(56.87,148.75) R249.2
CSI_MIPI_LT_EN: length 2.4
  TOP w0.14: U4.10 50.66,142.37 50.47,142.17 R21.2 R20.1
CSI_MIPI_RSTZ: length 25.6
  TOP w0.14: U4.7 v1(52.96,144.2) ; J1.14 68.58,151.11 v1(69.07,151.6)
  L10_SIG03 w0.102: v1(52.96,144.2) 52.43,144.73 52.43,145.32 53.13,146.02 60.59,146.02 61.13,145.48 62.16,145.48 66.47,149.79 67.51,149.79 69.07,151.36 v1(69.07,151.6)
  BOTTOM w0.14: R255.1 v1(52.96,144.2)
CSI_REFCLK: length 34.4
  TOP w0.14: R34.2 59.79,136.18 v1(59.95,136.34) ; J1.10 TP1.1 v1(67.08,152.41)
  L10_SIG03 w0.102: v1(67.08,152.41) 68.02,153.35 72.24,153.35 72.91,152.68 73.27,152.68 73.74,152.21 73.74,148.33 72.08,146.67 70.14,146.67 60.41,136.94 60.41,136.8 v1(59.95,136.34)
CSI_RSTZ: length 15.8
  TOP w0.14: v1(47.84,145.82) 48.23,145.82 49.01,146.59 U2.10 ; U4.14 52.96,138.51 v1(53.46,138.01)
  L03_SIG01 w0.102: v1(53.46,138.01) 52,139.47 50.13,139.47 47.91,141.69 47.91,143.79 47.48,144.22 47.48,145.45 v1(47.84,145.82)
CSI_SEL1: length 3.2
  TOP w0.14: R39.2 74.31,131.13 73.28,131.13 72.83,131.58 U8.16
CSI_SEL2: length 38.3
  TOP w0.14: v1(54.52,150.06) 54.02,149.56 U2.20 ; U8.17 73.33,131.82 73.61,131.53 74.22,131.53 74.4,131.71 R38.2 v1(75,132.37)
  BOTTOM w0.14: v1(75,132.37) 74.62,131.99 67.85,131.99 67.47,132.37 67.47,133.18 67.24,133.41 66.68,133.41 66.47,133.62 66.47,133.84 66.07,134.24 65.48,134.24 61.27,138.46 61.27,139.57 59.01,141.82 56.92,141.82 56.1,142.64 56.1,145.11 56.38,145.39 56.38,149.05 55.73,149.71 54.86,149.71 54.52,150.05 v1(54.52,150.06)
CSI_VLDO_SEL: length 12.2
  TOP w0.14: U2.23 v1(53.6,151.06)
  L10_SIG03 w0.102: v1(53.6,151.06) 54.03,151.49 56.61,151.49 60.05,148.04 v1(60.05,147.51)
  BOTTOM w0.14: v1(60.05,147.51) 60.25,147.32 R251.1 60.25,146.7 59.87,146.32 59.36,146.32 59.04,146.64 U50.1
DEBOUNCE_CAN_FD_WKUP: length 10.3
  TOP w0.14: SW1.2 SW1.3 D3.2 C110.2 R149.2 8.86,56.53 9.35,57.01 U35.1
DEBOUNCE_GPIO_INT_MCU_SOC: length 17.7
  TOP w0.14: SW5.3 SW5.2 44.53,17.83 44.54,17.83 v1(44.62,17.83)
  BOTTOM w0.14: C484.2 40.44,17.83 39.54,16.93 38.67,16.93 38.42,17.18 38.42,18.4 38.57,18.55 38.82,18.55 38.99,18.72 U108.3 ; C484.2 R538.2 D12.2 44.53,17.83 44.54,17.83 v1(44.62,17.83) ; C484.2 41.72,18.48 41.57,18.63 Q13.2
DEBOUNCE_MCU_RESETZ: length 27.1
  TOP w0.14: Q3.2 48.71,40.09 48.61,40 C134.2 R183.2 v1(47.32,39.33) 46.66,38.67 TP70.1
  L03_SIG01 w0.102: v1(47.32,39.33) 47.32,39.31 44.99,36.97 44.99,34.58 43.46,33.06 43.46,25.44 40.2,22.18 v1(40.2,20.26)
  BOTTOM w0.14: U108.1 39.99,20.05 v1(40.2,20.26)
DEBOUNCE_SOC_WARMRESETN: length 16.6
  TOP w0.14: v1(37.91,17.83) SW4.2 SW4.3
  BOTTOM w0.14: Q14.2 C485.2 R539.2 D13.2 v1(37.91,17.83) 38.06,17.99 38.06,20.67 38.99,21.6 U108.6
DIR: length 15.6
  TOP w0.132: v1(50.87,29.25) 47.13,32.99 v1(42.11,32.99)
  BOTTOM w0.14: R480.1 50.72,28.85 50.87,28.99 v1(50.87,29.25) 52.06,29.25 52.16,29.15 U98.2 ; U101.2 v1(42.11,32.99)
DRAIN1: length 3.2
  BOTTOM w0.203: U90.19 19.38,47.96 v1(19.01,47.6) ; v1(18,45.66) 17.69,45.36 U90.8 ; v1(18,47.6) 17.78,47.81 U90.15
  vias: v1(18,46.63) v1(19.01,46.63) v1(19.01,45.66)
DRAIN2: length 3.2
  BOTTOM w0.203: v1(18,44.67) 17.71,44.96 U90.7 ; U90.56 17.78,42.52 v1(18,42.74) ; U90.52 19.38,42.37 v1(19.01,42.74)
  vias: v1(18,43.71) v1(19.01,44.67) v1(19.01,43.71)
EEPROM_A0: length 1.2
  TOP w0.132: U38.1 17.66,53.99 17.4,54.25 R151.2
EEPROM_A1: length 1.1
  TOP w0.132: U38.2 R154.1
EEPROM_A2: length 1.2
  TOP w0.132: R156.1 17.23,52.73 17.51,53.01 17.66,53.01 17.68,52.99 U38.3
EEPROM_WP: length 1.7
  TOP w0.132: R155.1 22.28,53.49 U38.7
EMMC_RSTN: length 10.8
  TOP w0.14: v1(58.15,71.55) R133.2 U32.4 ; U28.K5 56.67,78.26 v1(56.42,78.26)
  L10_SIG03 w0.102: v1(56.42,78.26) 56.69,77.99 57.81,77.99 58.42,77.38 58.42,71.82 v1(58.15,71.55)
EN_DRV_OUT: length 2.9
  TOP w0.14: U27.29 12.73,83.04 12.45,83.33 11.84,83.33 10.85,84.31 TP31.1
EN_LM5141_ON: length 90.9
  TOP w0.14: v1(14.53,101.65) 14.58,101.7 R81.2
  L03_SIG01 w0.102: v1(14.53,101.65) 14.58,101.65 15.05,102.12 16.28,102.12 17.03,101.37 17.03,95.92 16.45,95.35 16.45,93.45 13.99,90.99 11.72,90.99 10.44,89.72 10.44,84.32 9.03,82.91 9.03,67.47 9.73,66.77 9.73,65.4 10.61,64.52 10.61,60.03 15.22,55.41 v1(15.22,50.78)
  L10_SIG03 w0.102: v1(32.63,42.13) 32.44,42.33 30.74,42.33 29.93,41.52 26.2,41.52 25.53,40.85 24.18,40.85 23.37,41.66 17.85,41.66 16.98,42.54 16.98,49.4 15.56,50.81 15.26,50.81 v1(15.22,50.78)
  BOTTOM w0.14: R444.1 32.63,41.58 v1(32.63,42.13) 32.63,42.42 33.53,43.32 U89.23
ETH1_EARTH:
  vias: v1(76.68,85.2) v1(76.68,84.34) v1(76.68,83.48) v1(80.93,97.04) v1(80.93,95.52) v1(80.93,93.99) v1(80.93,92.47) v1(82.45,97.04) v1(82.45,95.52) v1(82.45,93.99) v1(82.45,92.47) v1(83.97,97.04) v1(83.97,95.52) v1(83.97,93.99) v1(83.97,92.47)
ETH2_EARTH:
  vias: v1(76.8,107.76) v1(76.8,106.9) v1(76.8,106.03) v1(80.93,119.6) v1(80.93,118.07) v1(80.93,116.55) v1(80.93,115.03) v1(82.45,119.6) v1(82.45,118.07) v1(82.45,116.55) v1(82.45,115.03) v1(83.97,119.6) v1(83.97,118.07) v1(83.97,116.55) v1(83.97,115.03)
ETH_CAN_INH: length 2.8
  TOP w0.14: R75.2 R76.2 14.66,104.07 14.84,103.9 14.84,103.31 R82.1
ETH_CAN_INH_PREREG: length 0.9
  TOP w0.14: R76.1 14.37,102.93 R81.1
ETH_CAN_INH_SOC: length 9.8
  TOP w0.14: R73.1 14.7,104.97 R65.2 16.37,104.05 16.37,102.22 17.93,100.66 19.39,100.66 19.66,100.4 R88.1
EXP_CLKOUT0: length 28.4
  TOP w0.14: R59.1 22.75,110.47 18.71,110.47 18.19,109.94 16.2,109.94 16.06,109.81 v1(15.64,109.81)
  L10_SIG03 w0.102: v1(15.64,109.81) 15.54,109.91 15.54,110.57 14.62,111.49 14.62,113.42 15.11,113.9 15.11,121.42 15.72,122.03 15.72,123.78 15.49,124.01 15.49,124.82 15.89,125.23 v1(16.4,125.23)
  BOTTOM w0.14: J3.7 16.85,126.74 16.4,126.29 v1(16.4,125.23)
EXP_EHRPWM1_B: length 47.8
  TOP w0.132: U18.B20 v1(31.48,110.86)
  L05_SIG02 w0.102: v1(31.48,110.86) 31.7,110.86 32.1,110.47 34.09,110.47 34.28,110.27 34.28,109.85 34.47,109.67 35.67,109.67 35.88,109.45 35.88,107.5 36.11,107.26 36.45,107.26 36.68,107.03 36.68,106.7 36.91,106.47 42.11,106.47 42.28,106.63 42.28,107.03 42.51,107.26 42.86,107.26 43.08,107.48 43.08,107.83 43.31,108.07 44.45,108.07 44.68,108.29 44.68,112.66 47.48,115.46 51.56,115.46 54.74,118.63 54.74,124.98 53.95,125.77 52.89,125.77 51.29,127.37 50.7,127.37 J3.33
EXP_GPIO0_14: length 24.9
  TOP w0.14: U10.7 29.51,124.67 28.96,124.12 v1(28.4,124.12)
  L05_SIG02 w0.102: J3.22 33.07,132.3 24.03,132.3 23.31,131.57 23.31,127.05 25.58,124.78 27.74,124.78 v1(28.4,124.12)
EXP_GPIO0_14_LT: length 43.7
  TOP w0.132: U18.G20 v1(35.48,110.86)
  TOP w0.14: v1(33.07,124.41) 33.07,124.44 32.79,124.73 31.45,124.73 31.39,124.67 U10.2
  L10_SIG03 w0.102: v1(35.48,110.86) 35.51,110.86 35.88,111.24 35.88,112.65 35.6,112.93 35.09,112.93 31.94,116.09 28.25,116.09 26.79,114.63 26.79,113.79 25.83,112.82 25.31,112.82 24.59,112.1 22.21,112.1 21.81,112.5 21.81,113.15 22.08,113.41 22.08,119.59 22.6,120.11 22.6,121.17 24.87,123.44 26.2,123.44 27.45,124.69 30.18,124.69 30.42,124.44 33.05,124.44 v1(33.07,124.41)
EXP_GPIO0_32: length 18.2
  TOP w0.14: J3.30 46.05,129.48 46.05,127.39 45.27,126.61 42.85,126.61 42.09,125.85 42.09,123.2 39.32,120.44 39.32,119.67 39.52,119.47 40.31,119.47 40.7,119.08 R52.1
EXP_GPIO0_33: length 34.6
  TOP w0.132: U18.L17 v1(38.68,108.46)
  L05_SIG02 w0.102: v1(38.68,108.46) 39.11,108.46 39.47,108.83 39.47,110.15 39.79,110.47 40.45,110.47 40.68,110.7 40.68,111.09 40.86,111.26 41.27,111.26 41.48,111.48 41.48,112.61 41.48,112.61 41.48,112.63 45.32,116.47 51.08,116.47 53.8,119.19 53.8,123.63 50.93,126.51 49.03,126.51 J3.31
EXP_GPIO0_36: length 37.5
  TOP w0.132: U18.M18 v1(40.28,109.26)
  L05_SIG02 w0.102: J3.29 45.93,129.35 48.08,129.35 48.45,128.99 48.45,127.49 49.15,126.79 50.98,126.79 54.05,123.72 54.05,119.03 51.26,116.24 45.82,116.24 42.28,112.7 42.28,110.69 42.06,110.48 42.06,110.48 42.05,110.47 40.91,110.47 40.68,110.23 40.68,109.8 40.28,109.4 v1(40.28,109.26)
EXP_GPIO0_38: length 67.6
  TOP w0.132: U18.R17 v1(42.68,108.46)
  L05_SIG02 w0.102: v1(42.68,108.46) 42.28,108.06 42.28,107.49 42.05,107.26 36.91,107.26 36.91,107.27 36.68,107.5 36.68,107.53 36.68,107.53 36.68,108.68 36.86,108.86 37.25,108.86 37.48,109.1 37.48,109.44 37.71,109.67 38.05,109.67 38.28,109.9 38.28,110.23 38.51,110.46 38.9,110.46 39.88,111.44 39.88,112.63 40.11,112.86 40.41,112.86 44.85,117.31 50.77,117.31 52.41,118.95 52.41,123.88 51.06,125.24 48.41,125.24 47.32,126.33 26.88,126.33 26.61,126.06 25.99,126.06 25.74,126.32 25.74,129.47 J3.16
EXP_GPIO0_39: length 53.8
  TOP w0.132: U18.K17 v1(37.88,108.46)
  L05_SIG02 w0.102: v1(37.88,108.46) 38.28,108.86 38.85,108.86 38.85,108.87 38.86,108.87 39.17,109.18 39.17,110.44 39.99,111.26 40.45,111.26 40.68,111.5 40.68,111.83 41.07,112.22 41.07,112.72 45.07,116.73 50.93,116.73 52.88,118.68 52.88,124.18 51.36,125.69 48.8,125.69 47.61,126.88 31.38,126.88 30.76,127.5 30.76,129.53 J3.18
EXP_GPIO0_40/PR0_ECAP0_IN_APWM_: length 42.2
  TOP w0.132: U18.K18 v1(37.88,109.26)
  L05_SIG02 w0.102: J3.32 48.65,129.42 48.65,127.69 49.28,127.06 51.13,127.06 52.86,125.34 53.95,125.34 54.51,124.78 54.51,118.78 51.46,115.74 46.92,115.74 43.88,112.7 43.88,109.07 43.68,108.86 41.71,108.86 41.7,108.85 41.48,108.63 41.48,108.3 41.25,108.07 41.22,108.07 41.22,108.06 37.71,108.06 37.48,108.3 37.48,108.74 37.88,109.14 v1(37.88,109.26)
EXP_GPIO0_41: length 32.5
  TOP w0.132: U18.M19 v1(40.28,110.06)
  TOP w0.14: v1(53.57,124.91) 53.93,125.26 53.93,127.18 J3.37
  L05_SIG02 w0.102: v1(40.28,110.06) 39.84,109.63 39.84,108.97 39.95,108.86 41.27,108.86 41.48,109.08 41.48,109.43 41.71,109.66 42.83,109.66 42.85,109.67 43.08,109.9 43.08,109.92 43.08,112.66 46.41,115.99 51.34,115.99 54.28,118.94 54.28,124.19 v1(53.57,124.91)
EXP_GPIO0_42: length 51.6
  TOP w0.132: U18.M21 v1(40.28,111.66)
  TOP w0.14: J3.13 24.47,127.84 25.71,126.6 v1(26.24,126.6)
  L05_SIG02 w0.102: v1(26.24,126.6) 47.43,126.6 48.57,125.46 51.18,125.46 52.65,124 52.65,118.85 50.85,117.06 45,117.06 40.71,112.77 40.71,112.28 40.28,111.84 v1(40.28,111.66)
EXP_GPIO1_22: length 87.1
  TOP w0.132: U18.F14 v1(34.68,106.06)
  TOP w0.14: v1(25.78,134.99) 25.78,129.43 J3.15
  L10_SIG03 w0.102: v1(25.78,134.99) 24.15,136.62 17.17,136.62 15.01,134.45 13.22,134.45 12.38,133.61 12.38,132.7 12.03,132.35 9.25,132.35 8.03,131.12 8.03,127.8 9.9,125.93 9.9,122.99 8.13,121.22 8.13,111.39 8.75,110.76 8.89,110.63 8.89,105.69 11.3,103.29 11.94,103.29 12.1,103.13 13.04,103.13 14.03,102.15 16.46,102.15 17.98,100.62 21.83,100.62 22.11,100.9 22.74,100.9 24.08,102.25 26.23,102.25 27.73,103.75 28.77,103.75 29.05,103.47 30.7,103.47 30.98,103.75 32.13,103.75 32.68,104.3 32.68,104.6 32.68,104.6 32.68,104.63 32.91,104.86 33.25,104.86 33.48,105.1 33.48,105.43 33.72,105.67 34.05,105.67 34.45,106.06 v1(34.68,106.06)
EXP_HAT_DETECT: length 104.3
  TOP w0.14: v1(51.88,45.3) 51.75,45.17 R172.1 ; v1(62.15,125.81) 61.23,125.81 59.99,127.06 58.63,127.06 J3.39
  L05_SIG02 w0.102: v1(62.15,125.81) 63.65,125.81 63.95,125.51 63.95,124.9 63.72,124.67 63.72,124.11 64.97,122.86 64.97,121.67 65.73,120.9 65.73,115.96 65.32,115.55 65.32,109.07 65.73,108.66 65.73,104.89 65.46,104.61 65.46,101.66 64.47,100.67 64.47,93.03 65.1,92.4 65.1,89.48 65.59,88.99 65.59,87.18 65.25,86.84 65.25,73.69 63.59,72.03 63.59,58.96 64.86,57.69 64.86,53.98 63.78,52.9 v1(63.12,52.9)
  BOTTOM w0.14: U92.8 51.95,45.22 v1(51.88,45.3) 51.88,45.83 52.19,46.14 52.19,47.05 51.46,47.77 51.46,49.77 52.4,50.71 55.5,50.71 56.98,52.19 57.22,52.19 62.26,52.19 62.97,52.9 v1(63.12,52.9)
EXP_I2C2_NINT0: length 2
  TOP w0.14: R17.2 42.77,146.17 U5.4
EXP_I2C2_SCL: length 65.4
  TOP w0.14: U5.6 v1(41.47,145.76)
  L10_SIG03 w0.102: v1(19.28,133.54) 19.41,133.67 23.01,133.67 23.93,132.75 33.81,132.75 35.03,133.97 38.18,133.97 39.29,132.86 43.59,132.86 44.5,133.77 44.5,135.4 45.05,135.95 45.53,135.95 47.64,138.06 49.24,138.06 49.61,138.44 49.61,138.91 51.97,141.27 51.97,143.9 49.37,146.5 46.98,146.5 46.74,146.26 41.97,146.26 v1(41.47,145.76)
  BOTTOM w0.14: R293.2 J3.5 14.31,128.97 15.57,130.24 15.57,131.69 16,132.12 18.8,132.12 19.28,132.6 v1(19.28,133.54)
EXP_I2C2_SDA: length 65.5
  TOP w0.14: v1(42.3,145.74) 42.12,145.56 U5.5
  L10_SIG03 w0.102: J3.3 10.53,129.44 10.53,131.66 10.99,132.12 12.25,132.12 13.66,133.52 14.96,133.52 17.22,135.78 24.31,135.78 25.69,134.4 27.26,134.4 28.14,135.28 33.88,135.28 35.47,136.87 42.18,136.87 44.37,139.06 48.56,139.06 49.63,140.13 50.12,140.13 50.83,140.85 50.83,142.2 51.14,142.51 51.14,143.99 49.46,145.67 48.38,145.67 47.94,145.23 42.81,145.23 v1(42.3,145.74)
  BOTTOM w0.14: R294.2 J3.3
EXP_PS_3V3_EN: length 169
  L03_SIG01 w0.102: v1(15.8,40.08) 15.39,40.08 14.56,40.91 14.56,55.03 10.94,58.66 8.2,58.66 7.19,59.67 6.09,59.67 5.64,59.22 v1(5.64,58.71)
  L10_SIG03 w0.102: v1(14.85,134.86) 13.76,135.95 12.34,135.95 12.11,136.17 7.06,136.17 6.58,135.7 6.58,131.66 7.39,130.86 7.39,127.48 9.37,125.49 9.37,123.25 7.57,121.45 7.57,110.91 4.85,108.19 4.85,106.21 3.26,104.62 3.26,103.92 1.98,102.63 1.98,90.83 1.02,89.87 1.02,67.56 1.64,66.94 1.64,65.42 1.05,64.83 1.05,59.67 2.01,58.71 v1(5.64,58.71) ; v1(15.8,40.08) 16.52,40.8 17.01,40.8 17.52,41.31 23.24,41.31 24,40.56 25.73,40.56 26.33,41.16 30.02,41.16 30.91,42.06 31.97,42.06 32.34,41.69 32.84,41.69 34.03,42.88 34.03,43.33 34.82,44.11 34.82,45.73 35.13,46.04 35.7,46.04 36.07,46.41 38.63,46.41 39.18,45.86 48.66,45.86 v1(50.26,47.45)
  BOTTOM w0.14: v1(14.85,134.86) 15.06,134.86 R286.2 16.3,134.53 U57.B2 ; U92.6 51.43,43.61 50.79,44.25 50.79,46.82 50.26,47.35 v1(50.26,47.45)
EXP_PS_5V0_EN: length 160
  L03_SIG01 w0.102: v1(14.67,39.29) 14.04,39.92 14.04,54.5 11.13,57.41 8.46,57.41 7.65,58.23 v1(6.4,58.23)
  L10_SIG03 w0.102: v1(51.16,47.05) 50.74,46.64 49.9,46.64 48.89,45.63 38.04,45.63 37.68,45.99 36.79,45.99 35.91,45.11 35.91,44.6 34.45,43.13 34.45,42.86 32.99,41.41 32,41.41 31.66,41.75 30.99,41.75 30.13,40.89 26.52,40.89 25.93,40.29 20.86,40.29 20.7,40.45 16.61,40.45 16.32,40.17 16.32,39.91 16.11,39.69 15.07,39.69 v1(14.67,39.29) ; v1(6.4,58.23) 2.04,58.23 0.79,59.48 0.79,90.8 1.53,91.54 1.53,104.84 4.55,107.86 4.55,108.85 6.09,110.39 6.09,111.08 6.66,111.65 6.66,121.43 6.25,121.83 6.25,126.91 7.16,127.82 7.16,130.76 4.6,133.32 4.6,137.78 v1(4.9,138.09)
  BOTTOM w0.14: U53.C2 5.61,137.69 5.51,137.78 R271.2 5.17,138.36 v1(4.9,138.09) ; U92.7 51.43,44.11 51.16,44.39 v1(51.16,47.05)
EXP_SPI0_CLK: length 25.9
  L10_SIG03 w0.102: J3.23 38.28,127.09 53.01,127.09 53.52,127.6 53.52,131.91 53.33,132.1 v1(53.33,135.14)
  BOTTOM w0.14: U55.2 v1(53.33,135.14)
EXP_SPI0_CS0: length 27.9
  L10_SIG03 w0.102: v1(58.83,137.74) 58.39,137.3 48.96,137.3 48.54,136.88 48.54,135.98 44.38,131.81 38.59,131.81 37.51,130.74 J3.24
  BOTTOM w0.14: U55.11 v1(58.83,137.74) ; R290.2 J3.24
EXP_SPI0_CS1: length 76.9
  TOP w0.132: U18.C16 v1(32.28,107.66)
  TOP w0.14: v1(36.06,132.49) 38.87,132.49 39.71,131.65 J3.26
  L10_SIG03 w0.102: v1(32.28,107.66) 32.05,107.66 31.65,107.26 30.4,107.26 30.08,107.58 29.26,107.58 28.1,106.41 27,106.41 25.33,104.74 16.04,104.74 12,108.77 12,109.86 12.52,110.37 12.52,121.92 12.09,122.34 12.09,123 12.52,123.42 12.52,124.42 14.38,126.28 19.48,126.28 20.86,127.65 20.86,132.12 21.36,132.63 22.76,132.63 23.53,131.86 34.31,131.86 34.94,132.49 v1(36.06,132.49)
  BOTTOM w0.14: R289.2 J3.26
EXP_SPI0_D0: length 39.2
  L10_SIG03 w0.102: J3.19 33.51,126.79 53.09,126.79 53.83,127.53 53.83,135.55 52.67,136.71 v1(48.99,136.71)
  BOTTOM w0.14: U55.5 50.85,137.09 50.47,136.71 v1(48.99,136.71)
EXP_SPI0_D1: length 87.8
  TOP w0.132: U18.E15 v1(33.88,106.86)
  TOP w0.14: v1(32.72,134.17) 32.72,134 33.33,133.38 33.33,129.5 J3.21
  L10_SIG03 w0.102: v1(32.72,134.17) 25.43,134.17 24.06,135.55 18.37,135.55 16.33,133.52 15.61,133.52 15.34,133.24 15.34,132.96 15.08,132.71 13.92,132.71 12.82,131.6 12.82,127.31 10.2,124.69 10.2,122.97 8.36,121.13 8.36,111.48 8.85,110.99 9.12,110.72 9.12,105.92 11.5,103.54 12.04,103.54 12.19,103.39 13.19,103.39 14.21,102.37 17.53,102.37 19.05,100.85 21.73,100.85 22.01,101.13 22.56,101.13 23.98,102.55 26.14,102.55 27.65,104.07 28.93,104.07 29.25,103.74 30.43,103.74 30.75,104.07 31.65,104.07 31.88,104.3 31.88,104.63 31.88,104.64 32.11,104.86 32.48,104.86 32.68,105.07 32.68,105.39 32.68,105.43 32.91,105.66 32.96,105.66 32.96,105.67 33.25,105.67 33.48,105.9 33.48,106.24 33.88,106.64 v1(33.88,106.86)
EXP_SPI2_CLK: length 141.6
  TOP w0.14: J3.12 20.75,131.92 8.64,131.92 7.87,131.15 7.87,127.84 v1(6.99,126.96)
  L05_SIG02 w0.102: v1(25.8,38.43) 24.97,38.43 24.21,37.68 22.87,37.68 22.41,38.14 22.41,39.97 22.99,40.54 22.99,41.22 22.44,41.77 19.94,41.77 18.2,40.03 18.2,39.69 16.75,38.24 13.31,38.24 11.82,39.74 11.82,52.28 10.38,53.72 7.05,53.72 1.08,59.69 1.08,64.16 1.6,64.68 1.6,66.89 1.35,67.15 1.35,74.33 1.78,74.77 1.78,76.32 1.1,76.99 1.1,89.83 1.97,90.7 1.97,96.06 3.65,97.75 3.65,102.05 4.27,102.68 4.27,104.34 3.98,104.63 3.98,105.41 4.33,105.76 4.33,107.38 4.8,107.86 4.8,118.03 9.63,122.85 9.63,125.36 8.03,126.96 v1(6.99,126.96)
  BOTTOM w0.14: U95.5 25.51,38.73 v1(25.8,38.43)
EXP_SPI2_CS0/EHRPWM0_A: length 178.3
  TOP w0.14: v1(21.95,132.25) 21.82,132.37 8.38,132.37 7.47,131.46 7.47,128.49 5.84,126.86 v1(5.84,126.35)
  L05_SIG02 w0.102: v1(5.84,126.35) 6.71,126.35 6.89,126.53 8.03,126.53 9.25,125.31 9.25,122.92 4.5,118.17 4.5,108.12 4,107.62 4,105.98 3.24,105.22 3.24,97.79 1.65,96.2 1.65,92.15 0.77,91.28 0.77,59.57 6.94,53.4 9.3,53.4 9.73,52.97 9.73,51.25 10.85,50.13 10.85,40.25 13.16,37.94 16.92,37.94 18.35,39.37 18.87,39.37 20.94,41.44 22.34,41.44 22.64,41.14 22.64,40.64 22.05,40.05 22.05,37.93 22.63,37.35 24.71,37.35 25.21,37.85 26.38,37.85 v1(26.91,37.32)
  L10_SIG03 w0.102: J3.35 51.06,129.55 23.88,129.55 23.19,130.24 23.19,131.48 22.43,132.25 v1(21.95,132.25)
  BOTTOM w0.14: U95.2 25.92,36.78 26.47,37.32 v1(26.91,37.32) ; R287.2 22.05,132.35 v1(21.95,132.25)
EXP_SPI2_CS1: length 49.3
  TOP w0.132: v1(29.73,109.51) 30.08,109.86 30.89,109.86 U18.A19
  TOP w0.14: v1(15.06,124.09) 15.06,124.58 16.53,126.04 17.57,126.04 18.49,126.96 20.69,126.96 J3.11
  L10_SIG03 w0.102: v1(15.06,124.09) 15.06,124.04 14.59,123.57 14.59,120.79 14.28,120.47 14.28,110.48 14.7,110.06 14.7,109.2 16.23,107.67 17.1,107.67 19.09,105.68 21.48,105.68 23.48,107.68 25.13,107.68 26,108.55 26.9,108.55 27.86,109.51 v1(29.73,109.51)
  BOTTOM w0.14: R288.2 21.16,132.28 20.68,131.79 20.68,129.45 J3.11
EXP_SPI2_CS2: length 81.5
  TOP w0.132: U18.B18 v1(31.48,109.26)
  TOP w0.14: J3.36 51.11,129.44 51.11,127.32 50.51,126.73 50.01,126.73 v1(49.41,126.12)
  L10_SIG03 w0.102: v1(31.48,109.26) 31.08,108.86 27.85,108.86 27.31,108.32 26.84,108.32 26.16,107.64 26.16,107.29 25.49,106.62 23.49,106.62 22.33,105.45 17.34,105.45 13.9,108.9 13.9,120.5 14.36,120.96 14.36,124.18 16.23,126.05 19.43,126.05 19.69,125.79 23.7,125.79 24.97,127.07 32.54,127.07 33.17,126.43 49.1,126.43 v1(49.41,126.12)
  BOTTOM w0.14: R291.2 J3.36
EXP_SPI2_D0: length 126.3
  L05_SIG02 w0.102: J3.40 56.24,129.5 56.24,127.32 56.77,126.79 58.46,126.79 58.47,126.78 59.48,126.78 60.29,125.96 60.7,125.96 61.13,125.53 61.13,124.9 61.64,124.39 62.71,124.39 64.38,122.72 64.38,115.93 64.86,115.45 64.86,109.56 63.07,107.76 63.07,106.08 63.8,105.36 63.8,102.4 63.48,102.08 63.48,100.65 63.65,100.47 63.65,90.06 64.27,89.44 64.27,77.13 62.13,74.98 62.13,67.78 61.65,67.3 61.65,62.95 62.54,62.07 v1(62.54,58.79)
  L10_SIG03 w0.102: v1(62.54,58.79) 62.59,58.74 62.59,54.06 57.13,48.6 52.63,48.6 51.78,47.75 51.78,46.92 51.22,46.36 50.06,46.36 49.09,45.39 37.62,45.39 37.1,44.87 36.53,44.87 34.71,43.05 34.71,42.66 33.19,41.13 v1(31.27,41.13)
  BOTTOM w0.14: v1(31.27,41.13) 31.27,39.64 31.01,39.38 U95.11
EXP_SPI2_D1/ECAP2_IN_APWM_OUT: length 135.1
  L05_SIG02 w0.102: v1(62.16,52.87) 62.35,53.06 62.35,57.91 62.98,58.55 62.98,62.18 61.9,63.26 61.9,67.22 62.38,67.7 62.38,74.91 64.56,77.09 64.56,91.67 63.92,92.31 63.92,100.73 63.72,100.93 63.72,101.99 64.03,102.3 64.03,104.56 64.69,105.21 64.69,108.54 65.09,108.95 65.09,115.54 64.71,115.92 64.71,122.71 62.81,124.62 62.32,124.62 62.02,124.92 62.02,125.28 61.08,126.22 60.57,126.22 58.6,128.19 58.6,131.23 57.89,131.94 56.14,131.94 J3.38
  L10_SIG03 w0.102: v1(62.16,52.87) 60.51,51.22 60.51,46.27 59.38,45.14 59.38,44.12 58.84,43.59 57.19,43.59 56.42,42.81 52.15,42.81 50.22,40.88 43.85,40.88 43.37,41.36 40.73,41.36 39.66,40.3 39.28,40.3 38.97,39.99 38.97,39.55 37.55,38.12 37.55,37.45 37.04,36.95 28.96,36.95 28.77,37.14 v1(28.77,37.37)
  BOTTOM w0.14: v1(28.77,37.37) 29.02,37.37 29.07,37.43 U95.14
EXP_UART5_RXD: length 47.4
  TOP w0.132: U18.B17 v1(31.48,108.46)
  TOP w0.14: J3.10 18.15,129.5 18.15,127.42 17.12,126.39 16.37,126.39 15,125.02 v1(14.57,125.02)
  L10_SIG03 w0.102: v1(31.48,108.46) 28.12,108.46 24.88,105.22 16.26,105.22 13.12,108.37 13.12,109.59 12.98,109.73 12.98,121.84 13.92,122.78 13.92,124.38 v1(14.57,125.02)
EXP_UART5_TXD: length 49
  TOP w0.132: U18.C18 v1(32.28,109.26)
  TOP w0.14: J3.8 15.54,129.43 15.54,126.47 v1(14.94,125.87)
  L10_SIG03 w0.102: v1(14.94,125.87) 14.4,125.87 12.75,124.21 12.75,123.33 12.4,122.98 12.4,122.44 12.75,122.09 12.75,109.62 12.89,109.48 12.89,108.27 16.17,105 25.08,105 26.72,106.64 27.79,106.64 29.21,108.07 32.45,108.07 32.68,108.3 U18.C18 v1(32.28,109.26)
EXT_CLKOUT0: length 55.3
  TOP w0.14: R60.1 v1(25.05,109.94) ; v1(31.65,134.65) 37.23,140.23 39.9,140.23 41.3,141.63 47.85,141.63 48.77,140.71 49.57,140.71 50.29,139.98 50.53,139.98 51.35,139.16 51.35,137.92 51,137.56 R28.1
  BOTTOM w0.14: v1(25.05,109.94) 25.75,109.94 27.04,111.23 27.04,119.1 28.84,120.91 28.84,126.87 28.29,127.43 28.29,132.06 30.88,134.65 v1(31.65,134.65)
EXT_CLKOUT0_R: length 11.1
  TOP w0.132: U18.B16 v1(31.48,107.66)
  TOP w0.14: R59.2 v1(23.84,109.27)
  BOTTOM w0.14: v1(31.48,107.66) 30.95,108.19 29.66,108.19 28.15,106.69 25.96,106.69 23.84,108.8 v1(23.84,109.27)
FT4232_DO: length 2.7
  BOTTOM w0.14: U113.4 13.26,22.91 13.46,23.11 13.46,23.12 R513.2 R508.1
FT4232_EECLK: length 11.2
  TOP w0.14: U48.62 19.82,21.09 19.25,21.66 13.27,21.66 v1(11.96,22.97)
  BOTTOM w0.14: R509.1 v1(11.96,22.97) U113.2
FT4232_EECS: length 12.9
  TOP w0.14: U48.63 19.32,21.09 19.04,21.36 12.82,21.36 v1(10.66,23.53)
  BOTTOM w0.14: v1(10.66,23.53) R510.1 11.2,22.98 11.31,22.87 U113.1
FT4232_EEDATA: length 11.9
  TOP w0.14: v1(12.9,24.07) 15.02,21.95 19.47,21.95 20.32,21.1 U48.61
  BOTTOM w0.14: U113.3 12.61,22.83 12.9,23.12 R513.1 v1(12.9,24.07)
FT4232_MCU_UART0_CTS_3V3: length 9.4
  TOP w0.14: U48.53 24.32,21.45 25.14,22.26 26.93,22.26 28.89,20.3 v1(28.89,18.84)
  BOTTOM w0.14: v1(28.89,18.84) 29.21,19.16 U110.12
FT4232_MCU_UART0_RTS_3V3: length 7.1
  TOP w0.14: v1(27.6,19.99) 27.01,19.39 27.01,18.72 26.72,18.44 24.74,18.44 23.82,19.36 U48.54
  BOTTOM w0.14: v1(27.6,19.99) 27.85,20.23 U110.14
FT4232_MCU_UART0_RX_3V3: length 3.3
  TOP w0.14: v1(27.99,19.16) 27.55,19.16 27.41,19.02 27.41,18.48 27.67,18.21 U48.48
  BOTTOM w0.14: v1(27.99,19.16) 27.99,19.66 28.17,19.83 U110.13
FT4232_MCU_UART0_TX_3V3: length 5.7
  TOP w0.14: U48.52 24.82,21.51 25.11,21.81 26.7,21.81 v1(27.6,20.9)
  BOTTOM w0.14: U110.15 27.87,20.63 v1(27.6,20.9)
FT4232_REF: length 1.9
  TOP w0.14: U48.6 v1(18.01,15.71)
  BOTTOM w0.14: v1(18.01,15.71) 17.78,15.94 R553.2
FT4232_RESET: length 3.2
  TOP w0.14: U48.14 15.98,11.71 15.71,11.44 15.56,11.44 C160.2 R235.1
FT4232_SOC_UART0_RX_3V3: length 9.3
  TOP w0.14: U48.16 v1(15.69,10.71)
  BOTTOM w0.14: v1(15.69,10.71) 16.69,9.71 21.32,9.71 21.58,9.97 21.58,10.55 21.11,11.02 U119.13
FT4232_SOC_UART0_TX_3V3: length 3.6
  TOP w0.14: U48.17 18.82,9.95 19.41,10.54 v1(19.91,10.54)
  BOTTOM w0.14: U119.15 20.31,10.94 v1(19.91,10.54)
FT4232_SOC_UART1_CTS_3V3: length 7
  TOP w0.14: v1(24.06,7.59) 24.32,7.85 U48.28
  BOTTOM w0.14: v1(24.06,7.59) 24.06,7.08 24.4,6.74 28.27,6.74 28.52,6.99 U123.12
FT4232_SOC_UART1_RTS_3V3: length 5.3
  TOP w0.14: v1(25.06,10.04) 24.82,9.79 U48.29
  BOTTOM w0.14: U123.14 26.54,8.06 25.06,9.55 v1(25.06,10.04)
FT4232_SOC_UART1_RX_3V3: length 6.6
  TOP w0.14: U48.26 23.32,7.83 v1(23.08,7.59)
  BOTTOM w0.14: U123.13 25.98,7.66 25.41,8.24 23.73,8.24 v1(23.08,7.59)
FT4232_SOC_UART1_TX_3V3: length 6.6
  TOP w0.14: U48.27 23.82,9.78 v1(24.08,10.04)
  BOTTOM w0.14: v1(24.08,10.04) 24.61,10.56 25.36,10.56 26.48,9.45 26.48,9 27.02,8.46 U123.15
FT4232_USB_DM: length 14.8
  TOP w0.102: 8.07,16.79 7.97,16.69 7.58,16.69 7.08,17.18 6.72,17.18 6.5,17.4 J17.2 ; 8.07,16.79 8.17,16.69 9.64,16.69 9.93,16.39 9.93,14.43 10.34,14.02 13.43,14.02 14.48,15.07 15.78,15.07 15.92,15.21 U48.7 ; 8.07,16.79 U46.5
FT4232_USB_DP: length 14.8
  TOP w0.102: U48.8 15.92,14.71 15.78,14.86 14.57,14.86 13.52,13.81 10.25,13.81 9.72,14.34 9.72,16.3 9.55,16.48 9.17,16.48 9.07,16.37 ; 9.07,16.37 8.96,16.48 7.49,16.48 6.99,16.97 6.72,16.97 6.5,16.75 J17.3 ; 9.07,16.37 U46.3
FT4232_USB_VBUS: length 3
  TOP w0.254: U46.1 v1(8.07,15.17)
  BOTTOM w0.254: 8.24,10.73 8.24,9.87 8.67,9.44 U121.4
  vias: v1(7.23,18.42) v1(8.15,18.42) v1(9.06,18.42)
FT4232_WKUP_UART0_CTS_3V3: length 2.3
  TOP w0.14: v1(26.88,13.95) 27.12,13.95 27.38,14.21 U48.40
  BOTTOM w0.14: U118.12 26.45,14.37 v1(26.88,13.95)
FT4232_WKUP_UART0_RTS_3V3: length 4.1
  TOP w0.14: U48.41 27.35,14.71 27.11,14.46 25.74,14.46 v1(25.46,14.74)
  BOTTOM w0.14: U118.14 25.64,14.57 v1(25.46,14.74)
FT4232_WKUP_UART0_RX_3V3: length 2.9
  TOP w0.14: U48.38 27.24,13.21 27.07,13.04 v1(26.28,13.04)
  BOTTOM w0.14: U118.13 26.04,13.28 v1(26.28,13.04)
FT4232_WKUP_UART0_TX_3V3: length 4
  TOP w0.14: v1(25.24,13.04) 25.68,13.47 27.06,13.47 27.3,13.71 U48.39
  BOTTOM w0.14: U118.15 v1(25.24,13.04)
FT_PWREN#: length 1.8
  TOP w0.14: U48.60 R228.1
GPIO1_23_INTN: length 151.4
  TOP w0.132: U18.C15 v1(32.28,106.86)
  L03_SIG01 w0.102: v1(49.39,39.23) 48.4,40.22 46.2,40.22 43.03,37.05 43.03,35.72 39.93,32.63 39.93,28.31 37.24,25.62 v1(37.24,24.46)
  L05_SIG02 w0.102: v1(32.28,106.86) 31.88,107.26 31.3,107.26 31.08,107.48 31.08,107.87 30.85,108.1 28.82,108.1 28.4,108.51 24.67,108.51 24.32,108.86 24.32,109.39 23.24,110.48 17.7,110.48 16.89,109.67 16.89,108.68 15.55,107.33 15.55,105.96 11.53,101.94 11.53,100.51 11.36,100.35 11.36,98.86 11.79,98.43 11.79,96.36 11.28,95.84 11.28,92.8 10.81,92.33 10.81,81.4 10.09,80.67 10.09,77.76 8.14,75.82 8.14,67.51 8.37,67.29 8.37,66.42 7.68,65.73 7.68,61.12 9.81,58.99 11.41,58.99 15.65,54.75 15.65,54.01 16,53.66 16.74,53.66 18.16,52.24 21,52.24 22.11,51.12 23.86,51.12 28.62,46.35 28.62,41.71 29.78,40.55 29.78,36.12 28.3,34.64 28.3,31.22 35.06,24.46 v1(37.24,24.46)
  BOTTOM w0.14: R448.1 v1(49.39,39.23) ; v1(37.24,24.46) 37.55,24.14 R512.2
GPIO2_BUF_EN: length 2.3
  BOTTOM w0.14: U102.5 60.91,27.29 60.65,27.03 60.48,27.03 R491.2 60.72,26.32 R494.1
GPIO_AUD_RSTN: length 12.4
  L10_SIG03 w0.102: v1(52.7,46.17) 52.7,46.19 52.85,46.34 55.13,46.34 55.63,46.84 v1(59.78,46.84)
  BOTTOM w0.14: v1(52.7,46.17) U92.9 ; v1(59.78,46.84) 60.21,46.41 R427.1 R432.2 U93.1
GPIO_CPSW1_RST: length 18.2
  TOP w0.14: v1(60.69,43.66) 60.92,43.44 R174.1 R175.1 62.68,43.44 62.86,43.25 U41.1
  L10_SIG03 w0.102: v1(60.69,43.66) 60.69,41.6 59.73,40.65 57.04,40.65 56.48,40.09 53.97,40.09 53.41,39.53 51.38,39.53 50.93,39.98 v1(50.93,40.58)
  BOTTOM w0.14: U92.2 51.35,41.61 50.93,41.19 v1(50.93,40.58)
GPIO_CPSW2_RST: length 144.6
  TOP w0.14: v1(53.66,149.08) 53.65,149.06 U2.19 ; U42.1 63.2,39.77 63.01,39.96 R181.1 R180.1 61.46,39.96 v1(60.98,40.44)
  L05_SIG02 w0.102: v1(60.98,40.44) 60.98,42.06 61.44,42.52 62.27,42.52 62.63,42.17 63.09,42.17 67.13,46.21 67.13,49.31 69.08,51.26 73.37,51.26 74.67,52.56 74.67,56.82 72.03,59.47 72.03,63.81 71.19,64.65 71.19,79.71 70.81,80.09 70.81,86.77 73.3,89.26 73.3,100.97 72.76,101.5 72.76,102.75 73.35,103.33 73.35,110.47 73.83,110.95 73.83,123.32 73.09,124.06 73.09,126.65 73.37,126.93 73.37,129.19 75.56,131.37 75.56,133.53 75.79,133.76 75.79,138.33 72.76,141.36 70.66,141.36 66.49,145.52 66.49,146 62.6,149.89 59.17,149.89 57.35,148.06 54.96,148.06 53.94,149.08 v1(53.66,149.08)
GPIO_EMMC_RSTN: length 31.1
  TOP w0.14: U32.1 R136.1 v1(61.4,67.86)
  L03_SIG01 w0.102: v1(61.4,67.86) 60.21,67.86 53.95,61.6 53.95,56.25 50.26,52.56 50.26,49.28 52.71,46.83 v1(53.2,46.83)
  BOTTOM w0.14: v1(53.2,46.83) U92.10
GPIO_HDMI_RSTN: length 16.3
  TOP w0.14: v1(45.63,43.5) 46.48,44.35 46.48,45.05 47.77,46.33 51.71,46.33 52.39,45.65 53.46,45.65 v1(54.7,46.89)
  BOTTOM w0.14: v1(45.63,43.5) 45.29,43.5 45,43.21 R438.1 R442.2 U94.1 ; v1(54.7,46.89) U92.13
GPIO_MCU_SOC: length 54.6
  L03_SIG01 w0.102: v1(30.15,60.87) 30.91,60.11 33.91,60.11 34.33,60.53 36.73,60.53 37.14,60.12 37.14,45.86 37.47,45.53 37.47,41.7 36.53,40.76 36.53,38.27 35.33,37.07 35.33,35.95 33.99,34.61 33.99,31.38 33.38,30.77 33.38,25.36 v1(32.77,24.75)
  BOTTOM w0.14: U108.5 38.49,23.15 R512.1 38.11,24.59 37.7,25.01 37.04,25.01 36.5,24.47 33.05,24.47 v1(32.77,24.75) ; v1(30.15,60.87) 29.87,60.59 R572.1
GPIO_MCU_SOC_INTN: length 49
  TOP w0.14: U18.B9 v1(31.48,101.27)
  L05_SIG02 w0.102: v1(27.41,66.31) 26.94,66.78 26.94,70.23 24,73.18 24,91.78 24.11,91.89 24.11,96.59 24.8,97.28 24.8,97.96 26.93,100.09 28.67,100.09 29.6,101.02 30.14,101.02 30.39,101.27 v1(31.48,101.27)
  BOTTOM w0.14: v1(27.41,66.31) 28.22,65.49 28.22,61.63 28.4,61.45 R572.2 R573.1
GPIO_OSPI_RSTN: length 52
  TOP w0.132: U18.G19 v1(35.48,110.06)
  TOP w0.14: v1(37.14,125.28) 37.67,124.75 39.01,124.75 39.2,124.93 R41.1 U11.1
  L10_SIG03 w0.102: v1(35.48,110.06) 35.45,110.06 35.08,110.43 35.08,112.52 35.08,112.52 35.08,112.63 34.85,112.86 34.76,112.86 31.77,115.85 28.34,115.85 27.13,114.64 27.13,113.22 25.68,111.77 21.39,111.77 20.81,112.35 20.81,113.42 21.05,113.65 21.05,119.48 21.81,120.24 21.81,121.24 23.46,122.89 23.46,122.89 23.68,123.11 23.68,123.12 24.29,123.73 26.01,123.73 27.29,125.01 36.88,125.01 v1(37.14,125.28)
HB_LM5141: length 6.1
  BOTTOM w0.254: D9.1 33.61,52.34 33.36,52.09 C412.2 33.36,49.92 35.03,48.25 U89.11
HDMI_AUDD1: length 7.4
  TOP w0.14: TP10.1 v1(27.54,124.14) ; v1(23.03,121.01) 23.19,121.18 U13.40
  L10_SIG03 w0.102: v1(23.03,121.01) 23.03,121.02 23.03,121.06 25.11,123.14 26.53,123.14 v1(27.54,124.14)
HDMI_AUDD2: length 6
  TOP w0.132: v1(23.86,121.01) 23.69,121.18 U13.39
  TOP w0.14: TP12.1 v1(27.51,122.82)
  L10_SIG03 w0.102: v1(27.51,122.82) 25.67,122.82 v1(23.86,121.01)
HDMI_AUDD3: length 2.2
  TOP w0.132: TP14.1 25.36,122.72 24.87,122.72 24.69,122.55 U13.37
HDMI_CEC: length 14
  TOP w0.14: v1(6.68,110.71) 7.41,110.71 7.67,110.45 12.47,110.45 13.1,111.08 13.1,111.41 14.96,113.27 U13.71
  BOTTOM w0.14: U58.1 v1(6.68,110.71)
HDMI_CEC_D: length 2
  TOP w0.14: U13.50 18.19,123.43 TP11.1
HDMI_CLK+: length 11.7
  TOP w0.089: J5.10 9.61,115.74 9.73,115.86 9.73,116.01 9.86,116.14 10.36,116.14 v1(10.6,115.91) 10.86,116.17 11.15,116.17 11.37,116.4 11.37,117.77 13.01,119.41 14.74,119.41 14.88,119.27 U13.59
  BOTTOM w0.089: v1(10.6,115.91) 10.36,116.14 9.83,116.14 9.6,115.91 U58.16
HDMI_CLK-: length 11.7
  TOP w0.089: J5.12 9.6,116.74 9.73,116.6 9.73,116.46 9.82,116.37 10.3,116.37 v1(10.6,116.67) 10.86,116.4 11.06,116.4 11.15,116.49 11.15,117.87 12.91,119.64 14.74,119.64 14.88,119.77 U13.58
  BOTTOM w0.089: U58.15 9.64,116.56 9.83,116.37 10.3,116.37 v1(10.6,116.67)
HDMI_CONN_I2CSCL: length 7.8
  TOP w0.14: v1(6.23,115.26) 6.23,117.06 7.41,118.24 J5.15
  BOTTOM w0.14: U58.8 v1(6.23,115.26)
HDMI_CONN_I2CSDA: length 6.7
  TOP w0.14: v1(6.25,117.9) 7.09,118.74 J5.16
  BOTTOM w0.14: v1(6.25,117.9) 4.27,115.91 U58.9
HDMI_CONNCEC: length 8.3
  TOP w0.14: v1(6.25,114.16) 6.63,114.54 6.63,116.69 7.18,117.24 J5.13
  BOTTOM w0.14: U58.7 5.8,114.61 v1(6.25,114.16)
HDMI_EXTSWING: length 1.6
  TOP w0.14: v1(16.23,120.73) 16.19,120.77 16.17,120.77 16.17,120.77 U13.56
  BOTTOM w0.14: R308.1 15.94,121.02 v1(16.23,120.73)
HDMI_HPD: length 22.3
  TOP w0.14: U13.54 16.19,122.8 R47.1 15.83,123.48 15.66,123.65 14.13,123.65 v1(13.51,124.27)
  L05_SIG02 w0.102: v1(13.51,124.27) 12.36,123.13 12.09,123.13 8.8,119.84 8.8,118.09 7.6,116.88 7.6,114.19 7.29,113.88 6.78,113.88 v1(6.23,113.32)
  BOTTOM w0.14: v1(6.23,113.32) 5.26,113.32 4.6,112.66 U58.4
HDMI_I2C_SCL: length 27.6
  TOP w0.14: U13.49 v1(18.69,122.87)
  L05_SIG02 w0.102: v1(18.69,122.87) 18.69,121.96 19.18,121.48 19.18,120.94 19.59,120.54 19.59,120.21 19.31,119.93 17.45,119.93 17.07,120.31 16.06,120.31 15.51,119.76 11.22,119.76 8.13,116.68 8.13,112.76 7.65,112.28 v1(7.06,112.28)
  BOTTOM w0.14: v1(18.69,122.87) 18.5,123.06 R298.2 ; U58.2 6.14,111.36 v1(7.06,112.28)
HDMI_I2C_SDA: length 25.1
  TOP w0.14: v1(18.95,120.41) 19.19,120.65 U13.48
  L05_SIG02 w0.102: v1(18.95,120.41) 18.47,120.41 17.33,121.55 14.94,121.55 13.85,120.46 11.58,120.46 7.88,116.75 7.88,113.2 7.47,112.79 6.58,112.79 v1(6.23,112.43)
  BOTTOM w0.14: v1(6.23,112.43) 5.79,112 2.96,112 U58.3 ; R310.2 19.15,120.21 v1(18.95,120.41)
HDMI_INTN: length 158.9
  TOP w0.14: v1(15.9,124.42) 15.9,123.91 16.5,123.32 16.98,123.32 17.22,123.55 R45.2 17.51,123.27 17.19,122.95 U13.52
  L05_SIG02 w0.102: v1(15.9,124.42) 15.69,124.64 14.32,124.64 14.07,124.88 11.89,124.88 10.59,123.59 10.59,122.34 8.28,120.03 8.28,118.35 5.57,115.63 5.57,107.15 5.18,106.77 5.18,104.76 5.39,104.56 5.39,99.89 4.89,99.4 4.89,92.46 5.29,92.07 5.29,89.87 5.54,89.61 5.54,85.82 6.89,84.48 6.89,81.85 7.21,81.52 7.21,79.21 5.08,77.07 5.08,76.47 5.4,76.15 5.4,70.81 4.32,69.73 4.32,66.33 4.02,66.03 4.02,59.26 8.37,54.9 10.39,54.9 11.03,54.27 12.42,54.27 13.67,53.02 13.67,39.71 14.53,38.84 15.84,38.84 v1(16.27,39.27)
  L10_SIG03 w0.102: v1(16.27,39.27) 16.9,38.65 19.7,38.65 20.55,37.8 29.25,37.8 29.66,37.38 32.03,37.38 32.51,37.86 36.45,37.86 38.06,39.47 38.06,39.95 38.73,40.62 39.52,40.62 40.59,41.68 40.59,41.97 40.97,42.36 44.2,42.36 45.44,41.11 50.12,41.11 52.56,43.54 52.56,44.49 52.86,44.79 58.03,44.79 v1(58.72,44.11)
  BOTTOM w0.14: U92.17 58.22,44.61 v1(58.72,44.11)
HDMI_MSTRCLK: length 3
  TOP w0.132: U13.38 24.19,122.83 24.89,123.53 25.22,123.53 25.45,123.76 R43.2
HDMI_PCLK: length 47.2
  TOP w0.14: v1(20.34,114.1) 24.44,114.1 24.61,114.27 U13.22
  L03_SIG01 w0.102: v1(20.34,114.1) 20.96,114.72 20.96,119.1 22.6,120.74 22.6,121.4 24.95,123.75 25.26,123.75 26.31,124.8 36.26,124.8 36.63,124.44 40.75,124.44 41.31,123.87 42.24,123.87 47.48,118.63 v1(47.48,114.24)
  BOTTOM w0.14: R318.2 v1(47.48,114.24)
HDMI_RSTN: length 145.8
  TOP w0.132: U13.51 v1(17.69,122.82)
  L05_SIG02 w0.102: v1(15.46,39.27) 15.46,39.29 13.9,40.86 13.9,53.58 11.74,55.74 7.9,55.74 4.24,59.39 4.24,65.86 4.54,66.16 4.54,69.57 5.74,70.77 5.74,76.21 5.39,76.56 5.39,77.02 7.44,79.07 7.44,81.22 7.82,81.59 7.82,84.27 6.11,85.97 6.1,85.97 5.88,86.2 5.88,90.8 6.11,91.04 6.11,91.79 5.23,92.68 5.23,98.86 5.66,99.29 5.66,104.73 5.41,104.99 5.41,106.59 5.79,106.97 5.79,115.51 8.54,118.25 8.54,119.93 10.87,122.26 10.87,123.51 12.02,124.66 13.69,124.66 15.12,123.23 17.29,123.23 v1(17.69,122.82)
  L10_SIG03 w0.102: v1(15.46,39.27) 16.53,38.21 19.79,38.21 20.48,37.52 24.87,37.52 25.47,36.93 27.84,36.93 28.31,36.45 30.92,36.45 31.52,35.85 38.68,35.85 39.91,37.08 39.91,39.24 40.97,40.3 44.96,40.3 v1(45.98,39.28)
  BOTTOM w0.14: U94.4 R463.2 46.53,37.02 46.42,36.92 46,36.92 45.75,37.17 45.75,38.09 45.98,38.32 v1(45.98,39.28)
HDMI_TX0+: length 12.4
  TOP w0.089: U13.62 14.88,117.77 14.74,117.91 13.78,117.91 12.23,116.36 12.23,115.06 11.79,114.62 11.5,114.62 v1(11.23,114.36) 10.98,114.61 9.83,114.61 9.73,114.51 9.73,114.34 9.63,114.24 J5.7
  BOTTOM w0.089: v1(11.23,114.36) 10.91,114.67 9.8,114.67 9.69,114.78 9.37,114.78 9.21,114.61 U58.18
HDMI_TX0-: length 12.4
  TOP w0.089: U13.61 14.88,118.27 14.74,118.14 13.69,118.14 12.01,116.46 12.01,115.16 11.7,114.85 11.5,114.85 v1(11.23,115.12) 10.95,114.84 9.83,114.84 9.73,114.94 9.73,115.1 9.6,115.24 J5.9
  BOTTOM w0.089: v1(11.23,115.12) 11.02,114.9 9.89,114.9 9.69,115.1 9.38,115.1 9.22,115.26 U58.17
HDMI_TX1+: length 11.9
  TOP w0.089: J5.4 9.63,112.74 9.73,112.84 9.73,113.01 9.83,113.11 10.42,113.11 v1(10.67,112.86) 10.94,113.12 11.82,113.12 13.08,114.38 13.08,115.72 13.77,116.41 14.74,116.41 14.88,116.27 U13.65
  BOTTOM w0.089: v1(10.67,112.86) 10.67,112.92 10.45,113.14 10.29,113.14 10.03,112.87 9.75,112.87 9.54,112.66 U58.21
HDMI_TX1-: length 11.9
  TOP w0.089: J5.6 9.6,113.74 9.73,113.6 9.73,113.44 9.83,113.34 10.39,113.34 v1(10.67,113.62) 10.94,113.35 11.73,113.35 12.85,114.47 12.85,115.81 13.67,116.64 14.74,116.64 14.88,116.77 U13.64
  BOTTOM w0.089: U58.20 9.56,113.31 9.77,113.1 9.93,113.1 10.2,113.36 10.46,113.36 10.67,113.58 v1(10.67,113.62)
HDMI_TX2+: length 12.2
  TOP w0.089: U13.68 14.88,114.77 14.74,114.91 14.24,114.91 13.91,114.57 13.91,113.26 12.27,111.62 11.32,111.62 v1(11.05,111.36) 10.8,111.61 9.83,111.61 9.73,111.51 9.73,111.34 9.63,111.24 J5.1
  BOTTOM w0.089: U58.23 9.64,111.36 9.88,111.61 10.8,111.61 v1(11.05,111.36)
HDMI_TX2-: length 12.2
  TOP w0.089: J5.3 9.6,112.24 9.73,112.1 9.73,111.94 9.83,111.84 10.77,111.84 v1(11.05,112.12) 11.32,111.85 12.18,111.85 13.68,113.35 13.68,114.67 14.15,115.14 14.74,115.14 14.88,115.27 U13.67
  BOTTOM w0.089: v1(11.05,112.12) 10.77,111.83 9.81,111.83 9.64,112.01 U58.22
HDMICONN_HPD: length 7.4
  TOP w0.14: J5.19 7.08,120.24 6.26,119.42 v1(6.26,118.82)
  BOTTOM w0.14: U58.10 4,116.56 v1(6.26,118.82)
HFOSC0_CLKOUT_32K: length 48.5
  TOP w0.132: U18.B10 v1(31.48,102.07)
  BOTTOM w0.14: R282.1 20.03,134.85 20.75,134.13 24.15,134.13 25.75,132.53 25.75,121.9 25.26,121.41 25.26,112.99 24.69,112.42 24.69,110.86 22.86,109.03 22.86,105.53 24.5,103.89 24.5,103 25.04,102.47 26.13,102.47 27.22,103.56 28.87,103.56 29.51,102.93 29.79,102.93 30.07,102.65 30.07,101.88 30.35,101.61 31.02,101.61 v1(31.48,102.07)
HO_LM5141: length 2.3
  BOTTOM w0.14: U89.13 36.65,46.86 37.05,47.26 37.05,47.74 37.22,47.91 R420.1
HOL_LM5141: length 11.8
  TOP w0.14: v1(42.05,52.85) 41.57,52.85 41.25,52.53 U39.4
  L03_SIG01 w0.102: v1(38.51,47.38) 38.76,47.64 38.76,49.56 v1(42.05,52.85)
  BOTTOM w0.14: U89.14 36.78,46.36 37.36,46.93 R420.2 38.37,46.93 38.51,47.07 v1(38.51,47.38)
HPLOUT: length 6.8
  TOP w0.254: J14.2 72.59,38.48 73.24,39.13 v1(75.86,39.13)
  BOTTOM w0.254: C430.2 v1(75.86,39.13)
HPLOUT_C: length 2.5
  BOTTOM w0.254: U88.18 74.66,42.23 C430.1
HPROUT: length 10.5
  TOP w0.254: J14.3 77.4,31.85 77.4,32.14 75.4,34.15 75.4,35.09 v1(72.92,37.56)
  BOTTOM w0.254: C431.2 72.27,38.22 v1(72.92,37.56)
HPROUT_C: length 2.5
  BOTTOM w0.254: U88.23 72.16,42.23 C431.1
INA_ALERT: length 83.8
  TOP w0.14: R67.2 4.35,105.43 4.06,105.14 R68.1 3.53,104.48 v1(3.69,104.33) ; TP38.1 v1(4.96,74.04) ; R109.2 v1(2.21,88.42)
  L10_SIG03 w0.102: v1(3.69,104.33) 3.69,103.87 2.83,103.02 2.83,93.96 2.36,93.49 2.36,90.78 1.81,90.23 1.81,88.82 v1(2.21,88.42) 2.21,85.57 1.43,84.78 1.43,76.65 4.03,74.04 v1(4.96,74.04) ; v1(22.36,67.33) 22.37,67.33 22.62,67.58 27.07,67.58 27.43,67.22 31.76,67.22 v1(32.46,66.51) 33.05,66.51 35.37,68.84 v1(37.6,68.84) 37.95,68.48 40.83,68.48 41.16,68.81 42.41,68.81 v1(42.92,68.3)
  BOTTOM w0.14: v1(4.96,74.04) 4.96,72.35 R377.2 5.62,72.05 6.72,70.96 7.5,70.96 10.44,68.01 13.19,68.01 13.52,67.68 14.81,67.68 15.34,68.21 16.33,68.21 16.71,67.83 18.69,67.83 19.21,68.35 21.03,68.35 21.68,67.7 22,67.7 22.36,67.35 v1(22.36,67.33) ; R387.2 32.59,66.39 v1(32.46,66.51) ; R386.2 v1(42.92,68.3) ; R385.2 v1(37.6,68.84)
IO_EXP1_INTN: length 1.8
  TOP w0.14: U2.32 48.51,152.55 47.66,153.4 R3.1
IO_EXP_ADDR: length 1.1
  BOTTOM w0.14: U100.26 46.63,27.24 R489.1
IO_EXP_INTN: length 3
  BOTTOM w0.14: R448.2 R451.1 52.15,39.56 52.53,39.56 52.7,39.73 U92.32
IO_EXP_TEST_LED: length 10.3
  TOP w0.14: R163.1 R164.2 v1(55.9,48.09)
  L03_SIG01 w0.102: v1(55.9,48.09) 56.96,47.03 56.96,41.89 v1(57.81,41.03)
  BOTTOM w0.14: v1(57.81,41.03) 57.03,41.03 U92.24
JTAG_CTI_RTCK: length 3.1
  TOP w0.14: J19.9 v1(38.62,15.39)
  BOTTOM w0.14: R562.1 38.87,15.15 v1(38.62,15.39)
JTAG_CTI_TCK: length 25.2
  TOP w0.132: J19.11 37.35,15.16 38.08,15.89 40.08,15.89 v1(40.94,16.75)
  L05_SIG02 w0.102: v1(44.34,22.24) 44.05,22.52 38.46,22.52 37.09,21.15 37.09,19.44 37.82,18.71 38.66,18.71 40.62,16.75 v1(40.94,16.75)
  BOTTOM w0.14: U117.1 40.21,16.02 v1(40.94,16.75) ; v1(44.34,22.24) 44.64,22.54 R519.1 45.09,22.85 44.46,23.49 R504.1 U107.1
JTAG_DIR: length 3.1
  BOTTOM w0.14: U114.4 49.46,20.27 49.86,20.67 50.01,20.67 50.01,20.68 50.52,20.68 ; 50.52,20.68 R521.2 ; 50.52,20.68 50.52,20.16 50.24,19.89 U114.5
