# Allegro board PROC135A_BRD.BRD (continued)
## Copper pours and planes (outline as drawn) (continued)
DGND on L05_SIG02 (solid shape): 17.61,51.58 17.62,51.57 17.64,51.56 19.49,49.72 19.5,49.7 19.52,49.7 19.76,49.7 19.78,49.7 19.8,49.68 19.86,49.61 19.86,49.59 19.86,49.57 19.85,49.45 19.89,49.33 19.9,49.32 19.89,49.29 19.84,49.21 19.82,49.19 19.8,49.18 18.54,49.18 18.52,49.19 18.5,49.2 17.17,50.53 17.15,50.55 17.15,50.57 17.16,50.66 17.17,50.68 17.2,51.17 16.71,51.15 16.68,51.13 16.6,51.12 16.58,51.13 16.56,51.14 16.21,51.49 16.2,51.51 16.2,51.54 16.2,51.56 16.23,51.58
DGND on L05_SIG02 (solid shape): 41.95,84.32 42.28,83.99 42.29,83.98 42.31,83.97 42.35,83.97 42.38,83.97 42.39,83.95 42.45,83.86 42.45,83.83 42.44,83.82 42.44,83.51 42.7,83.34 42.73,83.32 42.74,83.29 42.73,83.25 42.67,83.2 42.65,83.19 42.52,83.12 42.43,83 42.43,82.99 42.41,82.98 42.31,82.96 42.29,82.96 42.27,82.97 42.21,83.03 42.2,83.05 42.19,83.07 42.19,83.22 42.19,83.24 42.18,83.26 41.64,83.79 41.63,83.81 41.63,83.83 41.63,84.18 41.63,84.2 41.64,84.22 41.71,84.27 41.74,84.28 41.82,84.29 41.9,84.31 41.92,84.32
DGND on L05_SIG02 (solid shape): 34.21,97.42 34.24,97.43 34.28,97.42 34.31,97.4 34.33,97.39 34.75,97.39 34.77,97.39 34.8,97.35 34.81,97.33 34.81,96.98 34.81,96.96 34.82,96.94 35.16,96.61 35.17,96.6 35.19,96.59 35.51,96.59 35.53,96.59 35.55,96.58 35.59,96.53 35.6,96.52 35.61,96.5 35.61,96.1 35.6,96.08 35.59,96.06 35.53,96 35.43,95.99 35.36,95.98 35.35,95.97 35.32,95.98 34.99,96.31 34.98,96.34 34.99,96.35 34.91,96.7 34.57,96.78 34.55,96.77 34.52,96.78 34.19,97.11 34.19,97.14 34.19,97.15 34.21,97.26 34.2,97.37 34.19,97.38 34.2,97.41
DGND on L05_SIG02 (solid shape): 63,104.12 63.12,104.1 63.15,104.1 63.21,104.04 63.22,104.02 63.23,104 63.23,103.86 63.22,103.84 63.21,103.82 63.13,103.77 63.11,103.76 63.1,103.76 62.72,103.59 62.82,103.18 62.84,103.15 62.84,103.07 62.84,103.05 62.83,103.03 62.7,102.9 62.69,102.89 62.69,102.87 62.69,102.32 62.69,102.3 62.67,102.29 62.5,102.11 62.47,102.1 62.44,102.1 62.43,102.11 62.41,102.13 62.41,104.01 62.42,104.03 62.43,104.05 62.5,104.1 62.52,104.11 62.53,104.11 62.67,104.11 62.8,104.18
DGND on L05_SIG02 (solid shape): 58.8,150 58.83,149.99 58.86,149.95 58.85,149.92 57.26,148.33 57.22,148.32 55.66,148.32 55.64,148.32 55.58,148.45 55.58,148.48 55.61,148.51 55.65,148.56 55.67,148.61 55.69,148.66 55.7,148.71 55.78,148.78 56.54,148.78 56.54,148.73 56.55,148.68 56.56,148.63 56.59,148.58 56.62,148.54 56.65,148.5 56.7,148.47 56.74,148.45 56.79,148.43 56.84,148.42 56.89,148.42 56.95,148.43 57,148.45 57.04,148.47 57.08,148.5 57.12,148.54 57.15,148.58 57.17,148.63 57.19,148.68 57.2,148.73 57.2,148.78 57.19,148.83 57.17,148.88 57.15,148.93 57.12,148.97 57.08,149.01 57.04,149.04 57,149.06 56.95,149.08 56.89,149.08 56.84,149.08 56.79,149.08 56.74,149.06 56.7,149.04 56.65,149.01 56.62,148.97 56.59,148.93 56.56,148.88 56.55,148.83 56.54,148.78 55.78,148.78 56.35,149.35 56.38,149.37 57.34,149.37 57.37,149.38 57.98,149.99 58.02,150
DGND on L05_SIG02 (solid shape): 84.31,107.19 84.34,107.18 84.36,107.17 84.36,107.14 84.36,104.78 84.29,104.71 73.65,104.71 73.62,104.72 73.61,104.74 73.61,104.92 73.62,104.93 73.65,104.94 77.86,104.94 77.89,104.95 77.91,104.96 77.92,104.99 77.92,106.16 80.47,106.16 80.47,106.11 80.47,106.05 80.49,106 80.51,105.96 80.54,105.92 80.58,105.88 80.62,105.85 80.67,105.83 80.72,105.81 80.77,105.8 80.82,105.8 80.87,105.81 80.92,105.83 80.97,105.85 81.01,105.88 81.05,105.92 81.08,105.96 81.1,106 81.12,106.05 81.13,106.11 81.13,106.16 81.12,106.21 81.1,106.26 81.08,106.3 81.05,106.35 81.01,106.38 80.97,106.41 80.92,106.44 80.87,106.45 80.82,106.46 80.77,106.46 80.72,106.45 80.67,106.44 80.62,106.41 80.58,106.38 80.54,106.35 80.51,106.3 80.49,106.26 80.47,106.21 80.47,106.16 77.92,106.16 77.92,107.14 77.92,107.17 77.94,107.18 77.97,107.19
DGND on L05_SIG02 (solid shape): 11.75,77.34 11.77,77.35 11.79,77.36 11.88,77.35 11.9,77.33 12.1,77.22 12.33,77.26 12.34,77.27 12.37,77.27 12.46,77.21 12.48,77.2 12.49,77.17 12.49,75.67 12.48,75.65 12.47,75.63 11.39,74.55 11.38,74.53 11.38,74.51 11.38,71.99 11.37,71.96 11.35,71.94 11.27,71.89 11.25,71.89 11.24,71.89 11.14,71.91 11.05,71.9 11.03,71.9 11.01,71.91 10.94,71.96 10.93,71.98 10.92,72 10.92,74.41 10.93,74.45 10.91,74.88 10.47,74.91 10.46,74.9 10.43,74.9 10.34,74.95 10.32,74.97 10.31,74.99 10.31,75.88 10.31,75.9 10.33,75.92
DGND on L05_SIG02 (solid shape): 24,116.25 24.02,116.24 24.04,116.22 24.1,116.15 24.1,116.13 24.1,116.11 24.08,116.02 24.1,115.93 24.1,115.92 24.1,115.89 24.04,115.82 24.02,115.8 24,115.8 17.95,115.8 17.93,115.79 17.91,115.78 17.72,115.59 17.7,115.58 17.68,115.58 15.49,115.58 15.47,115.57 15.45,115.56 15.05,115.16 15.03,115.15 15.01,115.14 14.86,115.14 14.84,115.15 14.83,115.16 14.71,115.28 14.69,115.3 14.69,115.33 14.72,115.43 14.74,115.45 14.76,115.45 14.96,115.59 15,115.84 15,115.85 15.01,115.88 15.03,115.9 15.08,115.9 15.08,115.9 15.36,115.9 15.46,115.92 15.54,115.98 15.67,116.1 15.7,116.12 15.74,116.1 15.93,115.92 15.94,115.9 15.96,115.9 17.8,115.9 17.82,115.9 17.84,115.92 18.15,116.23 18.17,116.24 18.19,116.25
DGND on L05_SIG02 (solid shape): 44.17,108.95 44.24,108.94 44.34,108.93 44.41,108.87 44.42,108.86 44.43,108.83 44.41,108.8 44.36,108.79 44.06,108.72 43.95,108.43 43.95,108.4 43.89,108.34 43.87,108.32 43.85,108.32 43.23,108.32 43.21,108.32 43.19,108.3 42.84,107.95 42.83,107.93 42.83,107.91 42.83,107.61 42.82,107.59 42.81,107.57 42.77,107.53 42.76,107.52 42.74,107.52 42.59,107.52 42.55,107.53 42.53,107.57 42.53,107.94 42.54,107.96 42.55,107.97 42.7,108.13 42.73,108.14 42.94,108.26 43.01,108.5 43.01,108.51 43.01,108.53 43.07,108.59 43.09,108.61 43.11,108.61 43.76,108.61 43.78,108.61 43.8,108.63 44.12,108.95 44.15,108.96
DGND on L05_SIG02 (solid shape): 18.06,88.54 18.1,88.56 18.14,88.54 18.24,88.44 18.25,88.42 18.26,88.4 18.26,85.79 18.26,85.77 18.27,85.75 19.65,84.37 19.66,84.36 19.66,84.34 19.66,76.99 19.65,76.96 19.63,76.94 19.62,76.94 19.59,76.94 19.4,77.13 19.39,77.15 19.38,77.17 19.38,82.86 19.38,82.88 19.37,82.9 19.05,83.22 19.04,83.24 18.88,83.45 18.62,83.49 18.61,83.48 18.59,83.49 18.51,83.54 18.5,83.56 18.49,83.58 18.49,84.31 18.5,84.34 18.5,84.74 18.12,84.85 18.1,84.85 18.06,84.86 18.05,84.9 18.05,84.9 17.71,85.24 17.7,85.26 17.69,85.28 17.69,88.15 17.7,88.17 17.71,88.19
DGND on L05_SIG02 (solid shape): 17.2,82.64 17.32,82.53 17.34,82.52 17.36,82.51 17.57,82.51 17.59,82.51 17.6,82.5 17.75,82.35 17.77,82.33 17.77,82.31 17.77,77.09 17.77,77.08 17.78,77.06 18.8,76.04 18.81,76.03 18.81,76.01 18.81,75.42 18.81,75.4 18.79,75.38 18.72,75.33 18.69,75.32 18.68,75.33 18.27,75.1 18.5,74.69 18.52,74.69 18.53,74.67 18.56,74.57 18.56,74.54 18.55,74.52 18.49,74.46 18.47,74.45 18.45,74.45 18.35,74.46 18.33,74.48 18.33,74.49 18.15,74.66 17.9,74.66 17.89,74.65 17.86,74.65 17.78,74.71 17.76,74.73 17.76,74.75 17.76,75.88 17.75,75.9 17.74,75.91 17.14,76.51 17.13,76.53 17.13,76.55 17.13,82.6 17.14,82.62 17.16,82.64 17.17,82.65
DGND on L05_SIG02 (solid shape): 70.3,90.76 70.32,90.75 70.33,90.72 70.33,87.97 70.33,87.95 70.32,87.94 69.7,87.32 69.69,87.31 69.69,87.29 69.69,79.73 69.68,79.7 69.66,79.68 69.64,79.68 69.61,79.68 68.62,80.68 68.61,80.69 68.6,80.71 68.6,82.47 68.61,82.5 68.64,82.52 68.74,82.56 68.76,82.55 68.78,82.54 69.34,82.78 68.78,83.02 68.76,83.01 68.74,83.01 68.64,83.05 68.61,83.07 68.6,83.1 68.6,90.62 68.61,90.64 68.63,90.66 68.73,90.71 68.76,90.7 68.77,90.7 69.48,90.46 70.16,90.79 70.17,90.8 70.2,90.8
DGND on L05_SIG02 (solid shape): 20.22,129.92 20.24,129.9 20.25,129.87 20.25,127.44 20.25,127.42 20.26,127.4 21.01,126.65 21.02,126.63 21.02,126.61 21.01,126.52 20.99,126.5 20.98,126.49 20.91,125.97 21.43,126.05 21.44,126.06 21.46,126.07 21.55,126.08 21.57,126.08 21.61,126.04 21.62,126.02 21.62,124.04 21.61,124.02 21.6,124.01 21.39,123.79 21.34,123.78 21.32,123.79 21.25,123.84 21.24,123.86 21.23,123.88 21.23,124.45 21.23,124.47 21.22,124.48 18.55,127.15 18.54,127.17 18.53,127.19 18.53,129.87 18.54,129.89 18.56,129.91 18.66,129.96 18.69,129.95 18.7,129.94 19.39,129.69 20.08,129.95 20.09,129.96 20.12,129.96
DGND on L05_SIG02 (solid shape): 7.33,120.2 7.36,120.21 7.39,120.21 7.4,120.2 7.42,120.18 7.42,118.66 7.42,118.64 7.4,118.62 6.74,117.95 6.71,117.94 6.69,117.94 6.59,117.96 6.57,117.98 6.57,117.99 6.02,118.13 6.15,117.58 6.17,117.58 6.18,117.56 6.21,117.46 6.21,117.43 6.19,117.41 5.14,116.36 5.12,116.35 5.09,116.35 5.07,116.36 5.06,116.38 5.06,117.9 5.06,117.92 5.07,117.94 5.82,118.68 5.84,118.69 5.86,118.7 5.95,118.68 5.97,118.67 5.98,118.66 6.5,118.59 6.43,119.11 6.42,119.12 6.4,119.14 6.39,119.23 6.39,119.25 6.4,119.27
DGND on L05_SIG02 (solid shape): 42.06,60.2 42.08,60.19 42.1,60.18 43.38,58.9 43.39,58.88 43.4,58.86 43.4,56.6 43.4,56.58 43.41,56.56 44.86,55.12 44.87,55.1 44.87,55.08 44.87,55.01 44.87,54.99 44.86,54.97 44.79,54.91 44.77,54.91 44.72,54.92 41.63,58 41.62,58.03 41.62,58.06 41.63,58.07 41.65,58.09 41.96,58.09 41.98,58.09 41.99,58.1 42.52,58.63 42.54,58.64 42.73,59.2 42.17,59.01 42.16,58.99 41.78,58.61 41.77,58.6 41.75,58.6 35.88,58.6 35.85,58.61 35.83,58.63 35.82,58.64 35.83,58.67 36.81,59.65 36.82,59.67 36.82,59.69 36.82,59.82 36.89,59.96 36.9,60.09 36.9,60.12 36.96,60.18 36.98,60.19 37,60.2
DGND on L05_SIG02 (solid shape): 21.65,53.26 21.67,53.26 21.69,53.24 21.74,53.16 21.75,53.13 21.74,53.12 21.89,52.7 22.33,52.82 22.33,52.83 22.35,52.84 22.44,52.85 22.47,52.85 22.49,52.84 22.78,52.54 22.79,52.52 22.8,52.5 22.8,52.19 22.8,52.17 22.81,52.15 23.19,51.78 23.2,51.75 23.2,51.72 23.2,51.71 23.17,51.69 22.37,51.69 22.35,51.69 22.33,51.71 22.23,51.8 22.22,51.82 22.22,51.84 22.23,51.93 22.24,51.95 22.25,51.96 22.28,52.45 21.78,52.42 21.78,52.41 21.76,52.4 21.67,52.39 21.65,52.4 21.63,52.41 21.01,53.03 21,53.05 21,53.08 21.01,53.1 21.03,53.11 21.15,53.11 21.16,53.12 21.18,53.13 21.3,53.25 21.32,53.26 21.34,53.26
DGND on L05_SIG02 (solid shape): 36.48,45 36.96,44.51 36.98,44.48 36.98,44.46 36.94,44.36 36.92,44.34 36.91,44.34 36.8,43.71 37.23,44.18 37.22,44.19 37.22,44.22 37.28,44.31 37.29,44.32 37.32,44.33 37.49,44.33 37.52,44.33 37.53,44.31 37.59,44.23 37.59,44.21 37.59,44.2 37.66,43.85 38,43.77 38.01,43.77 38.03,43.77 38.11,43.71 38.12,43.69 38.13,43.67 38.13,41.41 38.13,41.39 38.14,41.37 38.39,41.12 38.41,41.1 38.4,41.07 38.4,41.05 38.37,41.04 38.15,41.04 38.13,41.04 38.12,41.05 36.42,42.75 36.41,42.77 36.4,42.79 36.4,44.95 36.41,44.98 36.43,45 36.45,45
DGND on L05_SIG02 (solid shape): 60.46,39.27 60.48,39.27 60.5,39.25 60.56,39.18 60.56,39.16 60.56,39.14 60.8,38.73 61.2,39 61.2,39.01 61.22,39.03 61.33,39.07 61.35,39.07 61.36,39.06 61.6,39 61.81,39.11 61.83,39.12 61.86,39.13 61.96,39.09 61.98,39.07 61.99,39.05 61.99,37.77 61.94,37.66 61.92,37.57 61.9,37.54 61.87,37.52 61.83,37.54 61.8,37.57 61.79,37.59 61.49,37.88 61.15,37.64 61.14,37.63 61.12,37.61 61.02,37.59 61,37.59 60.98,37.6 59.39,39.19 59.38,39.21 59.38,39.24 59.39,39.26 59.41,39.27
DGND on L05_SIG02 (solid shape): 16.62,121.29 16.64,121.29 16.66,121.27 16.72,121.19 16.72,121.16 16.71,121.15 16.92,120.7 17.34,120.95 17.34,120.97 17.36,120.99 17.46,121.02 17.49,121.02 17.51,121.01 18.25,120.27 18.26,120.24 18.26,120.21 18.26,120.2 18.23,120.18 17.58,120.18 17.56,120.19 17.54,120.2 17.19,120.55 17.18,120.56 17.16,120.56 16.65,120.56 16.63,120.57 16.61,120.58 16.56,120.65 16.55,120.67 16.55,120.68 16.18,121.06 15.93,120.59 15.94,120.58 15.93,120.54 15.42,120.03 15.4,120.02 15.38,120.02 11.62,120.02 11.59,120.03 11.58,120.05 11.57,120.06 11.58,120.09 11.68,120.19 11.69,120.2 11.71,120.21 13.93,120.21 13.95,120.21 13.97,120.22 15.03,121.28 15.04,121.29 15.06,121.29
DGND on L05_SIG02 (solid shape): 20.6,108.28 20.79,108.22 20.98,108.27 20.99,108.28 21.02,108.28 21.11,108.23 21.13,108.21 21.13,108.19 21.13,108.15 21.13,108.13 21.11,108.11 21.03,108.06 21,108.06 20.99,108.06 20.59,107.96 20.6,107.55 20.61,107.53 20.61,107.5 20.21,107.09 20.2,107.08 20.2,107.06 20.2,106.97 20.19,106.95 20.18,106.93 20.11,106.87 20.09,106.86 20.08,106.87 19.71,106.66 19.85,106.26 19.86,106.25 19.87,106.23 19.88,106.14 19.88,106.12 19.87,106.1 15.69,101.93 15.67,101.92 15.59,101.94 15.49,101.94 15.43,102 15.41,102.02 15.41,102.04 15.41,102.39 15.41,102.41 15.43,102.42 18.94,105.93 18.95,105.95 18.95,105.97 18.95,106.68 18.96,106.7 18.97,106.72 20.53,108.28 20.54,108.29
DGND on L05_SIG02 (solid shape): 41.8,88.97 41.82,88.97 41.84,88.96 42.19,88.61 42.2,88.6 42.22,88.59 42.3,88.59 42.32,88.59 42.34,88.58 42.39,88.51 42.4,88.48 42.58,88.17 42.94,88.21 42.95,88.22 42.98,88.22 43.08,88.18 43.1,88.16 43.11,88.13 43.11,88 43.1,87.97 43.08,87.95 42.98,87.91 42.95,87.91 42.94,87.92 42.71,87.99 42.48,87.88 42.46,87.87 42.44,87.87 42.37,87.87 42.35,87.87 42.33,87.88 42.11,87.99 41.87,87.92 41.85,87.91 41.76,87.92 41.71,87.96 41.68,87.99 41.67,88 41.66,88.02 41.66,88.1 41.67,88.13 41.68,88.14 41.84,88.46 41.68,88.78 41.67,88.8 41.66,88.83 41.66,88.9 41.67,88.93 41.68,88.94 41.72,88.97
DGND on L05_SIG02 (solid shape): 67.67,77.61 68.02,77.26 68.03,77.24 68.04,77.22 68.04,65.84 68.03,65.82 68.02,65.8 67.94,65.74 67.92,65.74 67.91,65.74 67.49,65.42 67.91,65.1 67.92,65.1 67.94,65.1 68.02,65.04 68.03,65.03 68.04,65 68.04,64.05 68.03,64.03 68.02,64.02 67.53,63.52 67.49,63.51 67.46,63.52 66.87,64.11 66.86,64.13 66.86,64.15 66.86,64.47 66.86,64.5 66.88,64.52 66.98,64.56 67.01,64.56 67.02,64.55 67.55,64.82 67.02,65.08 67.01,65.07 66.98,65.07 66.88,65.12 66.86,65.13 66.86,65.16 66.86,68.11 66.86,68.13 66.87,68.15 67.58,68.85 67.59,68.87 67.59,68.89 67.59,77.56 67.6,77.59 67.62,77.61 67.64,77.62
DGND on L05_SIG02 (solid shape): outline of 91 points within 43.64,34.86 49.74,39.5
DGND on L05_SIG02 (solid shape): 6.74,112.53 6.76,112.51 6.77,112.48 6.78,112.46 6.77,112.43 6.85,112.03 7.26,112.02 7.29,112.03 7.73,112.03 7.75,112.03 7.77,112.04 8.09,112.37 8.12,112.38 8.15,112.38 8.16,112.37 8.18,112.35 8.18,111.73 8.18,111.71 8.17,111.7 7.18,110.71 7.16,110.7 7.13,110.7 7.03,110.73 7.01,110.75 7.01,110.77 6.45,110.95 6.63,110.39 6.64,110.38 6.66,110.36 6.7,110.26 6.7,110.24 6.68,110.21 6.13,109.66 6.11,109.65 6.08,109.65 6.07,109.66 6.05,109.68 6.05,112.01 6.05,112.03 6.07,112.05 6.13,112.1 6.16,112.11 6.17,112.11 6.42,112.17 6.55,112.39 6.56,112.41 6.67,112.52 6.69,112.53
DGND on L05_SIG02 (solid shape): 33.07,66.71 33.09,66.71 33.11,66.7 33.82,65.99 33.83,65.98 33.85,65.98 35.62,65.98 35.64,65.98 35.65,65.99 35.91,66.25 35.95,66.26 35.98,66.25 36.47,65.76 36.49,65.75 36.5,65.75 39.05,65.75 39.08,65.74 39.1,65.71 39.14,65.61 39.13,65.57 39.11,65.57 38.71,64.85 38.98,64.07 38.99,64.06 38.99,64.03 38.95,63.93 38.93,63.9 38.9,63.9 35.43,63.9 35.4,63.9 35.38,63.93 35.34,64.03 35.35,64.06 35.36,64.07 35.31,65.49 33.89,65.44 33.87,65.42 33.78,65.42 33.76,65.43 33.74,65.44 32.79,66.39 32.78,66.42 32.78,66.43 32.79,66.51 32.79,66.59 32.78,66.6 32.79,66.62 32.84,66.69 32.86,66.71 32.88,66.71
DGND on L05_SIG02 (solid shape): 17.39,91.31 17.64,91.06 17.65,91.04 17.66,91.02 17.66,88.88 17.65,88.86 17.64,88.84 17.2,88.4 17.19,88.38 17.19,88.36 17.19,85.07 17.19,85.05 17.23,85 17.23,84.98 17.22,84.89 17.21,84.87 17.2,84.86 17.05,84.53 17.29,84.26 17.31,84.26 17.32,84.24 17.35,84.14 17.35,84.12 17.34,84.09 17.02,83.78 17.01,83.76 17.01,83.74 17.01,83.57 17,83.54 16.98,83.52 16.96,83.51 16.93,83.52 16.4,84.05 16.39,84.07 16.39,84.09 16.39,84.17 16.39,84.19 16.41,84.21 16.48,84.26 16.5,84.27 16.51,84.26 16.92,84.48 16.71,84.89 16.7,84.9 16.68,84.92 16.66,85.01 16.66,85.04 16.68,85.06 16.82,85.2 16.83,85.22 16.83,85.24 16.83,88.19 16.84,88.21 16.85,88.23 17.15,88.53 17.16,88.55 17.17,88.56 17.17,91.19 17.17,91.21 17.18,91.23 17.21,91.26 17.29,91.28 17.36,91.31
DGND on L05_SIG02 (solid shape): outline of 83 points within 13.85,76.39 14.86,87.12
DGND on L05_SIG02 (solid shape): 4.43,75.13 4.46,75.14 4.49,75.14 4.59,75.09 4.6,75.07 4.6,75.05 4.73,74.78 5.02,74.72 5.03,74.72 5.05,74.72 5.12,74.66 5.14,74.64 5.14,74.62 5.14,74.47 5.14,74.44 5.12,74.43 5.05,74.37 5.03,74.36 5.02,74.37 4.63,74.04 5.02,73.72 5.03,73.72 5.05,73.71 5.12,73.66 5.14,73.64 5.14,73.62 5.14,70.94 5.14,70.92 5.13,70.9 4.26,70.03 4.23,70.02 4.2,70.02 4.19,70.03 4.17,70.05 4.17,70.52 4.17,70.54 4.18,70.56 4.28,70.66 4.29,70.67 4.29,70.69 4.29,71.7 4.3,71.72 4.31,71.73 4.38,71.79 4.41,71.8 4.78,72.12 4.41,72.45 4.38,72.46 4.31,72.52 4.3,72.53 4.29,72.55 4.29,74.97 4.3,74.99 4.31,75
DGND on L05_SIG02 (solid shape): 60.45,99.11 60.47,99.1 60.49,99.08 60.64,98.97 60.82,98.95 60.83,98.95 60.85,98.94 60.92,98.88 60.93,98.87 60.94,98.85 60.94,98.62 60.93,98.6 60.92,98.58 60.09,97.75 60.08,97.73 60.07,97.71 60.07,89.85 60.08,89.83 60.09,89.81 60.64,89.25 60.65,89.24 60.66,89.22 60.66,88.94 60.65,88.91 60.82,88.4 61.24,88.73 61.24,88.75 61.26,88.78 61.36,88.82 61.39,88.83 61.42,88.81 62.59,87.64 62.6,87.63 62.6,87.61 62.6,86.26 62.59,86.23 62.57,86.21 62.55,86.21 62.52,86.21 60.98,87.76 60.96,87.77 60.95,87.77 60.61,87.77 60.59,87.78 60.57,87.79 59.83,88.52 59.82,88.54 59.82,88.56 59.82,90.93 59.82,90.95 59.81,90.96 59.61,91.16 59.6,91.18 59.59,91.2 59.59,97.42 59.6,97.44 59.61,97.46 59.91,97.76 59.92,97.78 59.92,97.8 59.92,98.84 59.93,98.86 59.94,98.88 60,98.94 60.03,98.94 60.2,98.97 60.34,99.1 60.37,99.11
DGND on L05_SIG02 (solid shape): 8.5,107.87 8.53,107.85 8.54,107.82 8.54,107.73 8.53,107.71 8.52,107.7 7.75,106.93 7.73,106.92 7.71,106.91 7.63,106.92 7.6,106.94 7.08,106.93 7.21,106.43 7.23,106.42 7.24,106.4 7.24,104.23 7.24,104.21 7.23,104.19 6.86,103.83 6.84,103.81 6.81,103.82 6.79,103.82 6.77,103.85 6.77,104.78 6.77,104.8 6.76,104.82 6.49,105.08 6.48,105.1 6.48,105.12 6.48,105.62 6.49,105.64 6.5,105.66 6.57,105.72 6.6,105.72 6.61,105.72 7.02,106.04 6.61,106.36 6.6,106.35 6.57,106.36 6.5,106.42 6.49,106.43 6.48,106.46 6.48,107.8 6.49,107.83 6.51,107.85 6.61,107.89 6.64,107.89 6.65,107.88 7.51,107.53 8.36,107.89 8.37,107.9 8.4,107.91
DGND on L05_SIG02 (solid shape): 31.05,99.01 31.07,99.01 31.09,98.99 31.15,98.93 31.15,98.9 31.21,98.67 31.4,98.54 31.42,98.53 31.75,98.21 31.77,98.2 31.79,98.19 31.85,98.19 31.87,98.19 31.89,98.18 31.94,98.11 31.95,98.08 31.96,97.98 32,97.89 32.01,97.87 32.01,97.78 32.03,97.68 32.09,97.59 32.23,97.45 32.29,97.4 32.37,97.38 32.38,97.37 32.41,97.35 32.41,96.95 32.41,96.93 32.42,96.91 32.5,96.84 32.51,96.8 32.5,96.76 32.49,96.75 32.45,96.75 32.44,96.76 32.31,96.79 32.18,96.78 32.17,96.78 32.14,96.78 31.8,97.13 31.79,97.15 31.8,97.17 31.77,97.43 31.56,97.59 31.54,97.6 31.21,97.92 31.19,97.93 31.17,97.94 31.11,97.94 31.09,97.94 31.07,97.95 31.02,98.02 31.01,98.05 30.85,98.35 30.51,98.35 30.48,98.34 29.85,98.34 29.83,98.35 29.81,98.37 29.8,98.38 29.81,98.41 30.39,99 30.41,99.01 30.42,99.01
DGND on L05_SIG02 (solid shape): 68.62,140.16 68.64,140.16 68.66,140.15 69.6,139.21 69.61,139.19 69.61,139.17 69.61,138.58 69.62,138.56 69.63,138.54 70.46,137.71 70.48,137.7 70.5,137.7 71.67,137.7 71.69,137.69 71.71,137.68 71.89,137.51 71.9,137.49 71.9,137.47 71.9,131.88 71.89,131.85 71.87,131.83 71.85,131.83 71.82,131.83 71.33,132.33 71.32,132.35 71.31,132.36 71.31,135.79 71.31,135.81 71.3,135.83 70.87,136.26 70.86,136.27 70.86,136.3 70.86,136.39 70.88,136.4 70.89,136.41 70.94,136.46 70.99,136.53 70.99,136.54 71.02,136.55 71.14,136.55 71.16,136.54 71.17,136.53 71.79,136.68 71.17,136.84 71.16,136.83 71.14,136.81 71.02,136.81 70.99,136.83 70.99,136.84 70.71,137.01 70.42,136.87 70.42,136.86 70.4,136.85 70.31,136.84 70.29,136.85 70.27,136.86 68.92,138.21 68.91,138.22 68.91,138.24 68.91,139.34 68.9,139.36 68.89,139.38 68.2,140.08 68.18,140.1 68.19,140.13 68.19,140.15 68.22,140.16
DGND on L05_SIG02 (solid shape): 32.63,111.69 32.66,111.7 32.7,111.69 32.74,111.64 32.75,111.62 32.88,111.4 33.11,111.34 33.15,111.33 33.21,111.27 33.22,111.26 33.23,111.23 33.23,111.18 33.23,111.16 33.24,111.14 33.54,110.84 33.55,110.73 33.51,110.72 32.71,110.72 32.69,110.72 32.67,110.74 32.61,110.8 32.61,110.83 32.4,111.17 32.02,111.07 31.99,111.05 31.9,111.04 31.88,111.04 31.87,111.06 31.82,111.1 31.8,111.12 31.78,111.12 31.71,111.12 31.59,111.18 31.49,111.2 31.46,111.21 31.44,111.25 31.46,111.28 31.5,111.33 31.53,111.34 31.73,111.44 31.81,111.65 31.83,111.69 31.86,111.7 31.9,111.69 31.94,111.64 31.95,111.62 32.3,111.33 32.61,111.65
DGND on L05_SIG02 (solid shape): 50.73,124.65 50.75,124.64 51.02,124.37 51.03,124.35 51.26,124.08 51.6,124.18 51.63,124.19 51.71,124.2 51.73,124.19 51.75,124.18 52.14,123.79 52.15,123.77 52.16,123.75 52.16,122.08 52.15,122.06 52.14,122.04 52.07,121.99 52.05,121.98 52.04,121.98 51.77,121.92 51.64,121.68 51.64,121.66 51.61,121.63 51.13,121.63 51.1,121.64 51.08,121.67 51.07,121.68 51.08,121.71 51.13,121.76 51.14,121.78 51.15,121.8 51.15,122.39 51.14,122.41 51.13,122.43 50.99,122.58 50.9,122.63 50.81,122.65 50.69,122.65 50.67,122.66 50.65,122.68 50.64,122.7 50.65,122.73 51.08,123.16 51.12,123.16 51.14,123.15 51.68,123.35 51.21,123.7 51.2,123.69 51.18,123.69 51.09,123.74 51.08,123.76 51.07,123.79 51.07,124.02 51.07,124.04 51.05,124.05 50.69,124.42 50.67,124.5 50.64,124.55 50.64,124.58 50.64,124.6 50.66,124.63 50.68,124.65
DGND on L05_SIG02 (solid shape): 62.46,123.83 62.48,123.83 62.5,123.81 63.1,123.21 63.11,123.19 63.11,123.17 63.1,123.08 63.09,123.06 63.08,123.05 63.01,122.54 63.53,122.6 63.53,122.61 63.55,122.63 63.64,122.64 63.67,122.64 63.69,122.62 63.81,122.5 63.82,122.49 63.82,122.47 63.82,121.37 63.81,121.34 63.79,121.32 63.78,121.31 63.75,121.32 62.6,122.47 62.59,122.49 62.58,122.51 62.58,122.55 62.59,122.57 62.33,123.1 62.06,122.57 62.07,122.54 62.07,122.29 62.08,122.28 62.09,122.26 63.48,120.87 63.49,120.85 63.49,120.83 63.49,113.21 63.49,113.19 63.47,113.17 63.37,113.12 63.35,113.12 63.34,113.13 63.27,113.16 63.18,113.19 62.77,113.59 62.76,113.61 62.76,113.63 62.76,114.56 62.76,114.58 62.77,114.6 63,114.82 63.01,114.84 63.01,114.86 63.01,120.89 63.01,120.91 63,120.93 61.55,122.37 61.54,122.39 61.54,122.41 61.54,123.56 61.53,123.58 61.52,123.59 61.37,123.74 61.36,123.77 61.36,123.8 61.37,123.81 61.39,123.83
DGND on L05_SIG02 (solid shape): outline of 92 points within 18.22,131.82 23.25,138.64
DGND on L05_SIG02 (solid shape): 11.15,147.81 11.17,147.83 11.2,147.83 11.3,147.8 11.31,147.78 11.32,147.77 11.53,147.55 11.83,147.6 11.86,147.61 26.54,147.61 26.57,147.6 26.59,147.58 26.6,147.56 26.59,147.53 23.59,144.53 23.57,144.52 23.55,144.51 15.08,144.51 15.06,144.51 15.05,144.5 13.5,142.95 13.48,142.94 13.46,142.93 12.11,142.93 12.09,142.94 12.07,142.95 12.02,143.03 12.01,143.05 12.02,143.07 11.98,143.34 11.75,143.5 11.73,143.5 10.78,144.45 10.77,144.47 10.77,144.49 10.77,144.6 10.77,144.63 10.8,144.65 10.81,144.66 10.84,144.65 11.39,144.11 11.39,144.08 11.95,143.9 11.77,144.46 11.74,144.47 11.1,145.11 11.09,145.12 11.09,145.14 11.09,146.43 11.1,146.45 11.12,146.47 11.2,146.52 11.23,146.52 11.24,146.51 11.75,146.79 11.24,147.07 11.23,147.07 11.2,147.06 11.12,147.11 11.1,147.13 11.09,147.16 11.09,147.73 11.09,147.75 11.1,147.77
DGND on L05_SIG02 (solid shape): 60.41,149.64 60.44,149.63 60.46,149.61 60.51,149.51 60.5,149.48 60.49,149.47 61.27,147.79 62.04,149.47 62.03,149.48 62.03,149.51 62.07,149.61 62.09,149.63 62.12,149.64 62.48,149.64 62.5,149.63 62.51,149.62 66.22,145.91 66.23,145.9 66.24,145.88 66.24,145.44 66.24,145.42 66.25,145.4 70.54,141.12 70.55,141.11 70.57,141.1 72.64,141.1 72.66,141.1 72.67,141.09 72.77,140.99 72.79,140.96 72.79,140.93 72.78,140.92 72.75,140.9 69.87,140.9 69.85,140.9 69.83,140.91 67.68,143.07 67.66,143.08 67.64,143.08 66.48,143.08 66.46,143.09 66.45,143.1 62.3,147.24 62.29,147.25 62.27,147.26 60.46,147.26 60.44,147.26 60.42,147.28 60.36,147.36 60.36,147.38 60.36,147.4 60.13,147.84 59.73,147.54 59.72,147.53 59.71,147.5 59.61,147.47 59.58,147.46 59.55,147.48 59.1,147.93 59.09,147.94 59.07,147.94 57.71,147.94 57.68,147.95 57.66,147.98 57.66,147.99 57.66,148.02 59.27,149.62 59.28,149.63 59.3,149.64
DGND on L05_SIG02 (solid shape): outline of 122 points within 62.16,62.26 65.32,87.55
DGND on L05_SIG02 (solid shape): 40.71,95.79 40.74,95.78 40.76,95.73 41.03,95.34 41.41,95.63 41.42,95.66 41.46,95.68 41.5,95.66 41.55,95.61 41.56,95.59 41.68,95.4 41.9,95.34 41.93,95.33 41.99,95.27 42,95.25 42.01,95.23 42.01,94.66 42.01,94.64 42.02,94.62 42.25,94.39 42.26,94.37 42.26,94.34 42.23,94.24 42.21,94.22 42.19,94.22 42.05,94.17 41.96,94.06 41.95,94.06 41.9,94 41.86,93.99 41.82,94 41.77,94.06 41.76,94.06 41.47,94.23 41.18,94.04 41.17,94.03 41.14,94.01 41.1,94.03 41.06,94.07 41.05,94.09 41.04,94.11 41.04,94.31 41.04,94.33 41.03,94.35 40.41,94.96 40.39,94.97 40.37,94.98 39.51,94.98 39.49,94.97 39.47,94.96 39.12,94.61 39.09,94.59 39.06,94.6 39.05,94.6 39.03,94.63 39.03,94.85 39.04,94.87 39.05,94.89 39.79,95.63 39.81,95.64 39.84,95.64 39.94,95.62 39.96,95.6 39.96,95.58 40.35,95.34 40.6,95.73 40.62,95.78 40.65,95.79
DGND on L05_SIG02 (solid shape): outline of 148 points within 58.66,130.54 64.49,134.35
DGND on L05_SIG02 (solid shape): 33.11,95.79 33.13,95.79 33.15,95.78 33.19,95.73 33.2,95.72 33.21,95.7 33.21,95.31 33.2,95.28 33.18,95.26 33.16,95.26 33.13,95.26 33.1,95.29 33.08,95.31 33.06,95.31 32.77,95.31 32.65,95.28 32.55,95.22 32.49,95.15 32.45,95.15 32.44,95.16 31.99,95.03 32.11,94.58 32.14,94.55 32.14,94.53 32.14,94.15 32.14,94.13 32.16,94.11 32.29,93.97 32.3,93.96 32.31,93.94 32.31,93.89 32.29,93.86 32.26,93.84 31.46,93.84 31.44,93.84 31.43,93.83 31.06,93.46 31.04,93.44 31.01,93.45 30.99,93.45 30.97,93.48 30.97,93.85 30.98,93.87 30.99,93.89 31.34,94.24 31.35,94.25 31.35,94.27 31.35,94.43 31.36,94.45 31.37,94.47 31.43,94.53 31.46,94.53 31.81,94.84 31.51,95.19 31.48,95.21 31.47,95.24 31.48,95.28 31.54,95.34 31.56,95.34 31.73,95.45 31.81,95.63 31.82,95.66 31.86,95.68 31.9,95.66 31.95,95.61 31.96,95.59 32.33,95.34 32.61,95.68 32.62,95.71 32.67,95.78 32.69,95.79 32.71,95.79
DGND on L05_SIG02 (solid shape): outline of 144 points within 70.5,101.71 73.09,111.38
DGND on L05_SIG02 (solid shape): outline of 135 points within 61.39,107.96 64.31,112.56
DGND on L05_SIG02 (solid shape): outline of 135 points within 42.6,44.85 46.95,61.74
DGND on L05_SIG02 (solid shape): outline of 140 points within 57,43.5 63.91,46.28
DGND on L05_SIG02 (solid shape): outline of 144 points within 61.44,121.1 65.97,126.29
DGND on L05_SIG02 (solid shape): outline of 93 points within 13.43,128.98 16.87,139.44
DGND on L05_SIG02 (solid shape): 40.86,87.65 40.88,87.66 40.91,87.66 41.01,87.63 41.03,87.61 41.03,87.59 41.32,87.27 41.73,87.39 41.76,87.41 41.85,87.42 41.9,87.39 41.91,87.36 41.91,87.25 41.9,87.23 41.88,87.22 41.72,86.67 42.27,86.51 42.3,86.51 42.32,86.51 42.35,86.49 42.37,86.47 42.38,86.42 42.39,86.41 42.69,86.11 42.7,86.1 42.72,86.09 42.75,86.08 42.77,86.04 42.77,86.02 42.77,85.99 42.74,85.89 42.74,85.79 42.74,85.78 42.73,85.76 42.68,85.69 42.66,85.68 42.64,85.67 42.14,85.67 42.12,85.67 42.11,85.66 41.9,85.45 41.84,85.36 41.82,85.26 41.82,85.04 41.82,85.02 41.81,85.01 41.76,84.95 41.64,84.95 41.63,84.98 41.63,85.3 41.61,85.41 41.55,85.5 41.33,85.71 41.32,85.72 41.3,85.72 41.23,85.72 41.2,85.73 41.19,85.75 41.13,85.83 41.13,85.86 41.14,85.87 41.18,86.15 41.03,86.38 41.02,86.4 41.01,86.43 41.01,86.5 41.02,86.53 41.03,86.54 41.1,87.12 40.52,87.18 40.49,87.17 40.45,87.18 40.27,87.37 40.25,87.4 40.25,87.43 40.26,87.44 40.29,87.46 40.65,87.46 40.66,87.46 40.68,87.47
DGND on L05_SIG02 (solid shape): 34.85,83.97 34.87,83.97 34.89,83.96 35.25,83.6 35.26,83.58 35.51,83.34 35.83,83.45 35.85,83.46 35.87,83.46 35.94,83.46 35.96,83.46 35.98,83.45 36.23,83.33 36.48,83.45 36.49,83.46 36.51,83.46 36.6,83.46 36.62,83.46 36.63,83.45 36.78,83.35 36.95,83.34 37,83.33 37.02,83.29 37.02,83.24 37,83.2 36.95,83.19 36.78,83.18 36.63,83.08 36.61,83.07 36.59,83.07 36.52,83.07 36.5,83.07 36.48,83.08 35.97,83.07 36.09,82.57 36.1,82.56 36.11,82.54 36.13,82.45 36.13,82.43 36.11,82.4 36.09,82.38 36.07,82.36 36.07,82.34 36.07,82.06 36.07,82.04 36.06,82.02 35.99,81.95 35.95,81.94 35.92,81.95 35.91,81.96 35.9,81.99 35.9,82 35.73,82.36 35.33,82.28 35.32,82.27 35.3,82.27 35.21,82.27 35.19,82.27 35.14,82.32 35.09,82.35 35.02,82.43 35,82.47 35.02,82.5 35.09,82.58 35.1,82.58 35.23,83.01 34.81,83.17 34.8,83.17 34.78,83.17 34.7,83.23 34.68,83.24 34.67,83.27 34.67,83.92 34.69,83.96 34.72,83.97
DGND on L05_SIG02 (solid shape): 38.73,91.21 39.65,90.28 39.66,90.27 39.67,90.25 39.67,90.17 39.66,90.15 39.65,90.13 39.58,90.07 39.56,90.07 39.55,90.07 39.16,89.81 39.42,89.42 39.43,89.42 39.46,89.39 39.46,89.14 39.43,89.11 39.42,89.11 39.21,88.6 39.76,88.6 39.8,88.62 39.83,88.61 39.88,88.56 39.88,88.52 39.87,88.51 39.8,88.28 39.9,88.06 39.91,88.04 39.91,87.96 39.91,87.94 39.86,87.9 39.82,87.92 39.81,87.94 39.5,88.22 39.16,87.98 39.16,87.97 39.14,87.95 39.04,87.92 39.01,87.92 38.97,87.97 39,88.02 39.14,88.41 38.77,88.62 38.76,88.62 38.74,88.63 38.67,88.69 38.66,88.7 38.65,88.72 38.65,89.86 38.66,89.88 38.67,89.89 38.73,89.95 38.76,89.96 39.11,90.29 38.76,90.62 38.73,90.62 38.67,90.68 38.66,90.7 38.65,90.72 38.65,91.16 38.66,91.19 38.68,91.21 38.7,91.21
DGND on L05_SIG02 (solid shape): 21.78,121.23 21.8,121.23 21.82,121.21 21.87,121.14 21.88,121.12 21.88,121.1 22.2,120.69 22.52,121.1 22.51,121.12 22.52,121.14 22.57,121.21 22.59,121.23 22.64,121.23 22.66,121.21 22.71,121.14 22.72,121.11 22.71,121.1 23.03,120.68 23.35,121.1 23.35,121.11 23.35,121.14 23.41,121.21 23.43,121.23 23.45,121.23 23.52,121.23 23.55,121.22 23.57,121.18 23.56,121.16 23.83,120.68 24.18,121.1 24.17,121.11 24.18,121.14 24.24,121.21 24.25,121.23 24.28,121.23 25.88,121.23 25.9,121.23 25.92,121.21 25.97,121.14 25.98,121.12 25.98,121.1 25.97,121.01 25.99,120.91 25.99,120.9 25.99,120.87 25.93,120.8 25.91,120.78 25.89,120.77 25.28,120.77 25.26,120.77 25.24,120.76 24.95,120.47 24.93,120.45 24.9,120.46 24.8,120.49 24.78,120.51 24.78,120.52 24.4,120.8 24.12,120.42 24.13,120.41 24.12,120.39 24.06,120.32 24.04,120.31 24.02,120.3 21.08,120.3 21.06,120.31 21.04,120.32 20.74,120.62 20.73,120.64 20.73,120.67 20.75,120.76 20.76,120.78 20.78,120.79 20.94,120.92 20.99,121.12 20.99,121.15 21.05,121.21 21.07,121.23 21.09,121.23
DGND on L05_SIG02 (solid shape): 14.58,117.49 14.61,117.48 14.63,117.46 14.64,117.44 14.63,117.41 14.39,117.17 14.37,117.15 14.37,117.13 14.37,116.46 14.36,116.42 14.32,116.41 14.12,116.41 14.1,116.41 14.09,116.39 10.85,113.16 10.82,113.15 10.75,113.18 10.69,113.19 10.64,113.24 10.69,113.29 10.75,113.94 10.52,113.33 10.53,113.32 10.54,113.3 10.54,113.18 10.53,113.15 10.52,113.15 10.34,112.89 10.46,112.6 10.48,112.57 10.49,112.49 10.48,112.47 10.47,112.45 9.44,111.42 9.41,111.4 9.38,111.4 9.37,111.41 9.35,111.44 9.35,113.51 9.35,113.53 9.36,113.55 10.79,114.97 10.81,114.98 10.83,114.99 10.92,114.97 10.94,114.96 10.95,114.95 11,114.88 11.08,114.83 11.09,114.82 11.1,114.8 11.1,114.68 11.09,114.65 11.08,114.65 11.23,114.02 11.39,114.65 11.38,114.65 11.36,114.68 11.36,114.8 11.38,114.82 11.39,114.83 11.56,115.14 11.35,115.43 11.33,115.44 11.31,115.48 11.34,115.53 11.34,115.95 11.34,115.97 11.35,115.98 12.84,117.47 12.86,117.48 12.88,117.49
DGND on L05_SIG02 (solid shape): 65.22,43.94 65.24,43.96 65.27,43.95 65.29,43.95 65.31,43.92 65.31,42.55 65.3,42.52 65.28,42.5 65.18,42.46 65.15,42.46 65.14,42.47 64.62,42.12 65.24,42.07 65.25,42.08 65.27,42.1 65.36,42.12 65.39,42.12 65.41,42.1 65.64,41.88 65.65,41.86 65.65,41.84 65.65,39.06 65.64,39.03 65.62,39.01 65.52,38.96 65.5,38.97 65.48,38.98 65.22,39.05 64.99,38.91 64.99,38.9 64.97,38.89 64.88,38.88 64.86,38.88 64.84,38.89 64.27,39.46 64.26,39.47 64.26,39.49 64.26,40.16 64.26,40.18 64.28,40.2 64.35,40.26 64.37,40.26 64.38,40.26 64.8,40.58 64.38,40.9 64.37,40.89 64.35,40.9 64.28,40.96 64.26,40.97 64.26,41 64.26,41.05 64.25,41.07 64.24,41.09 64.05,41.28 64.04,41.29 64.04,41.31 64.04,41.44 64.05,41.47 63.78,42 63.52,41.47 63.53,41.45 63.53,41.42 63.52,41.4 63.5,41.38 63.48,41.37 63.45,41.38 63.32,41.51 63.31,41.54 63.22,41.72 63.04,41.81 63.02,41.82 63,41.85 63,41.86 63.01,41.9 63.05,41.91 63.17,41.91 63.19,41.92 63.21,41.93
DGND on L05_SIG02 (solid shape): outline of 90 points within 43.07,140.97 57.05,146.71
DGND on L05_SIG02 (solid shape): 24.41,47.31 25.63,46.08 25.64,46.06 25.65,46.03 25.63,45.99 25.6,45.98 25.56,45.99 25,45.8 25.49,45.47 25.51,45.48 25.53,45.48 25.62,45.43 25.64,45.41 25.65,45.39 25.65,43.2 25.64,43.17 25.62,43.15 25.53,43.11 25.5,43.11 25.49,43.12 24.96,42.8 25.56,42.67 25.57,42.68 25.59,42.69 25.68,42.7 25.7,42.7 25.72,42.68 27.64,40.76 27.65,40.75 27.66,40.73 27.66,39.64 27.65,39.61 27.62,39.59 27.61,39.59 27.58,39.59 27.26,39.92 27.24,39.93 27.22,39.93 26.44,39.93 26.42,39.93 26.4,39.95 25.42,40.92 25.41,40.94 25.41,40.96 25.41,41.4 25.4,41.42 25.39,41.44 25.3,41.54 25.28,41.56 25.28,41.58 25.31,41.68 25.32,41.7 25.34,41.7 25.47,42.25 24.92,42.12 24.91,42.11 24.9,42.09 24.8,42.07 24.77,42.07 24.75,42.08 24.34,42.49 24.33,42.5 24.33,42.52 24.33,44.96 24.34,44.99 24.35,45.01 24.44,45.06 24.46,45.06 24.47,45.06 24.94,45.36 24.47,45.65 24.46,45.65 24.44,45.65 24.35,45.7 24.34,45.72 24.33,45.75 24.33,47.26 24.34,47.29 24.36,47.31 24.38,47.31
DGND on L05_SIG02 (solid shape): outline of 87 points within 59.4,111.73 62.5,122.61
DGND on L05_SIG02 (solid shape): outline of 167 points within 22.63,18.69 26.86,35.05
DGND on L05_SIG02 (solid shape): outline of 110 points within 66.52,129.06 73.25,142.57
DGND on L05_SIG02 (solid shape): outline of 108 points within 15.33,68.47 17.83,82.93
DGND on L05_SIG02 (solid shape): outline of 96 points within 47.81,99.64 52.22,102.76
DGND on L05_SIG02 (solid shape): outline of 195 points within 40.28,36.42 49.53,46.62
DGND on L05_SIG02 (solid shape): outline of 202 points within 73.37,129.62 75.53,139.94
DGND on L05_SIG02 (solid shape): outline of 213 points within 64.29,10.71 67.41,17.73
DGND on L05_SIG02 (solid shape): outline of 221 points within 30.58,36.76 38.42,40.3
DGND on L05_SIG02 (solid shape): outline of 223 points within 51.51,16.4 63.48,19.39
DGND on L05_SIG02 (solid shape): outline of 214 points within 60.35,57.89 62.42,74.62
DGND on L05_SIG02 (solid shape): outline of 104 points within 67.08,49.7 74.41,64.03
DGND on L05_SIG02 (solid shape): outline of 205 points within 21.96,98.3 30.24,103.3
DGND on L05_SIG02 (solid shape): outline of 197 points within 41.87,87.9 46.05,90.69
DGND on L05_SIG02 (solid shape): outline of 247 points within 57.38,130.76 67.15,140.22
DGND on L05_SIG02 (solid shape): outline of 242 points within 55.99,26.59 60.79,31.41
DGND on L05_SIG02 (solid shape): outline of 245 points within 39.71,36.41 45.59,44.39
DGND on L05_SIG02 (solid shape): outline of 106 points within 28.65,107.97 34.03,110.21
DGND on L05_SIG02 (solid shape): outline of 117 points within 21.5,78.29 23.04,84.57
DGND on L05_SIG02 (solid shape): outline of 307 points within 4.5,56 9.76,70.56
DGND on L05_SIG02 (solid shape): outline of 280 points within 13.49,62.96 16.93,74.18
DGND on L05_SIG02 (solid shape): outline of 272 points within 32.24,99.53 34.83,104.16
DGND on L05_SIG02 (solid shape): outline of 313 points within 25.44,39.05 37.57,51.25
DGND on L05_SIG02 (solid shape): outline of 275 points within 42.95,83.15 46.39,87.43
DGND on L05_SIG02 (solid shape): outline of 322 points within 1.64,54.88 7.96,79.29
DGND on L05_SIG02 (solid shape): outline of 135 points within 22.38,105.92 32.78,109.73
DGND on L05_SIG02 (solid shape): outline of 342 points within 10.1,131.39 13.71,139.23
DGND on L05_SIG02 (solid shape): outline of 312 points within 14.47,137.79 29.55,149.56
DGND on L05_SIG02 (solid shape): outline of 354 points within 5.48,85 8.76,103.86
DGND on L05_SIG02 (solid shape): outline of 349 points within 9.06,118.37 19.04,125.37
DGND on L05_SIG02 (solid shape): outline of 360 points within 63.84,58 66.18,87.48
DGND on L05_SIG02 (solid shape): outline of 427 points within 21.13,60.53 32.95,70.34
DGND on L05_SIG02 (solid shape): outline of 461 points within 5.08,128.2 10.26,140.4
DGND on L05_SIG02 (solid shape): outline of 451 points within 52.4,75.01 63.22,97.94
DGND on L05_SIG02 (solid shape): outline of 473 points within 60.35,45.44 67.54,54.18
DGND on L05_SIG02 (solid shape): outline of 523 points within 32.17,84.93 35.98,91.14
DGND on L05_SIG02 (solid shape): outline of 719 points within 1.36,81.66 6.63,104
DGND on L05_SIG02 (solid shape): outline of 714 points within 37.34,16.77 49.58,25.4
DGND on L05_SIG02 (solid shape): outline of 667 points within 23.3,116.28 39.89,127.58
DGND on L05_SIG02 (solid shape): outline of 951 points within 0.64,28.13 18.92,59.28
DGND on L05_SIG02 (solid shape): outline of 972 points within 51.97,90.46 61.01,127.47
DGND on L05_SIG02 (solid shape): outline of 1126 points within 14.15,39.22 23.21,50.73
DGND on L05_SIG02 (solid shape): outline of 1281 points within 37.38,105.12 51.44,115.2
DGND on L05_SIG02 (solid shape): outline of 1393 points within 24.74,51.53 48.52,81.77
DGND on L05_SIG02 (solid shape): outline of 3566 points within 23.3,123.65 69.96,145.61
DGND on L05_SIG02 (solid shape): outline of 4409 points within 0.63,91.57 84.36,154.54
DGND on L05_SIG02 (solid shape): outline of 7178 points within 25.2,36.69 61.1,106.57
DGND on L05_SIG02 (solid shape): outline of 15830 points within 0.64,5.71 84.36,101.14
DGND on L10_SIG03 (solid shape): 8.15,80.54 8.17,80.56 8.2,80.55 8.22,80.55 8.23,80.52 8.23,73.37 8.23,73.35 8.22,73.33 8.01,73.12 7.99,73.11 7.96,73.11 7.94,73.12 7.93,73.14 7.93,80.3 7.93,80.32 7.94,80.34
DGND on L10_SIG03 (solid shape): 17.05,108.9 19.52,106.43 19.53,106.4 19.53,106.37 19.53,106.36 19.5,106.34 19.16,106.34 19.14,106.34 19.12,106.35 16.99,108.49 16.98,108.5 16.97,108.52 16.97,108.85 16.98,108.88 17,108.9 17.02,108.9
DGND on L10_SIG03 (solid shape): 17.4,102.12 17.42,102.12 17.44,102.11 18.58,100.96 18.59,100.94 18.59,100.91 18.58,100.89 18.56,100.88 18.11,100.88 18.09,100.88 18.07,100.89 16.93,102.03 16.92,102.06 16.92,102.09 16.93,102.1 16.95,102.12
DGND on L10_SIG03 (solid shape): 25.54,106.36 25.56,106.35 25.58,106.33 25.59,106.32 25.58,106.29 24.79,105.49 24.77,105.48 24.75,105.48 22.83,105.48 22.81,105.49 22.79,105.51 22.78,105.52 22.79,105.55 23.58,106.35 23.6,106.36 23.62,106.36
DGND on L10_SIG03 (solid shape): 27.17,112.9 27.2,112.92 27.22,112.91 27.24,112.91 27.26,112.88 27.26,112.43 27.25,112.41 27.24,112.4 26.28,111.43 26.26,111.42 26.24,111.42 25.81,111.42 25.78,111.43 25.76,111.45 25.76,111.46 25.76,111.49
DGND on L10_SIG03 (solid shape): 31.01,50.69 31.03,50.68 31.05,50.66 31.06,50.64 31.05,50.61 30.85,50.41 30.84,50.4 30.82,50.4 25.42,50.4 25.39,50.41 25.37,50.43 25.37,50.45 25.37,50.48 25.57,50.67 25.59,50.68 25.61,50.69
DGND on L10_SIG03 (solid shape): 45.98,121.17 46,121.17 46.01,121.16 46.6,120.57 46.61,120.56 46.61,120.54 46.61,120.02 46.6,119.99 46.58,119.97 46.57,119.96 46.54,119.97 45.42,121.08 45.41,121.11 45.41,121.14 45.41,121.15 45.44,121.17
DGND on L10_SIG03 (solid shape): 46.38,37.88 46.4,37.88 46.42,37.87 47.12,37.16 47.14,37.14 47.13,37.11 47.13,37.09 47.1,37.08 43.68,37.08 43.67,37.08 43.65,37.09 42.94,37.8 42.93,37.82 42.93,37.85 42.94,37.87 42.97,37.88
DGND on L10_SIG03 (solid shape): 56.64,69.53 57.62,68.55 57.63,68.53 57.64,68.51 57.64,68.05 57.63,68.03 57.61,68.01 57.59,68 57.56,68.01 56.58,68.99 56.57,69.01 56.56,69.03 56.56,69.48 56.57,69.51 56.6,69.53 56.61,69.54
DGND on L10_SIG03 (solid shape): 15.31,123.83 15.45,123.69 15.46,123.67 15.46,123.65 15.46,122.15 15.46,122.13 15.45,122.12 14.94,121.61 14.91,121.59 14.88,121.6 14.87,121.6 14.85,121.63 14.85,123.44 14.85,123.46 14.86,123.48 15.16,123.78 15.22,123.8 15.27,123.83
DGND on L10_SIG03 (solid shape): 28,121.75 28.02,121.74 28.04,121.72 28.05,121.71 28.04,121.68 27.28,120.91 27.26,120.9 27.24,120.89 26.67,120.89 26.63,120.91 26.63,121 27.37,121.74 27.39,121.75 27.41,121.75
DGND on L10_SIG03 (solid shape): 13.71,81.22 13.78,81.16 13.8,81.14 13.8,81.12 13.8,74.71 13.8,74.69 13.79,74.68 13.55,74.44 13.52,74.42 13.49,74.42 13.48,74.43 13.46,74.46 13.46,81.11 13.47,81.13 13.48,81.15 13.54,81.21 13.63,81.21 13.69,81.22
DGND on L10_SIG03 (solid shape): 43.24,41.11 43.26,41.11 43.28,41.09 43.51,40.87 43.52,40.84 43.52,40.81 43.51,40.8 43.49,40.78 40.73,40.78 40.71,40.78 40.69,40.77 39.88,39.95 39.86,39.93 39.83,39.93 39.74,39.94 39.72,39.95 39.72,39.97 39.76,40.05 39.77,40.05 40.82,41.09 40.83,41.11 40.85,41.11
DGND on L10_SIG03 (solid shape): 17,135.19 17.02,135.21 17.05,135.21 17.14,135.19 17.16,135.17 17.17,135.16 17.21,135.07 17.29,135 17.3,134.99 17.31,134.97 17.32,134.88 17.31,134.86 17.3,134.84 16.24,133.79 16.23,133.77 16.21,133.77 15.7,133.77 15.67,133.78 15.65,133.8 15.65,133.82 15.65,133.85
DGND on L10_SIG03 (solid shape): 37.21,38.25 37.23,38.27 37.26,38.27 37.28,38.26 37.29,38.23 37.29,37.58 37.29,37.56 37.28,37.54 36.95,37.22 36.94,37.21 36.92,37.2 32.34,37.2 32.31,37.21 32.29,37.23 32.28,37.25 32.29,37.28 32.6,37.59 32.62,37.6 32.64,37.61 36.54,37.61 36.56,37.61 36.57,37.62
DGND on L10_SIG03 (solid shape): 53.23,54.76 53.26,54.78 53.29,54.77 53.3,54.77 53.32,54.74 53.32,54.6 53.31,54.58 53.3,54.56 50.41,51.67 50.39,51.66 50.37,51.65 49.66,51.65 49.63,51.66 49.61,51.68 49.61,51.7 49.61,51.73 50.74,52.86 50.76,52.87 50.78,52.87 51.32,52.87 51.34,52.87 51.35,52.89
DGND on L10_SIG03 (solid shape): 61.03,37.67 61.05,37.67 61.07,37.66 61.12,37.6 61.13,37.57 61.14,37.46 61.19,37.36 61.2,37.35 61.2,37.32 61.15,37.23 61.13,37.21 61.1,37.2 58.14,37.2 58.12,37.21 58.1,37.23 58.09,37.25 58.1,37.28 58.48,37.66 58.5,37.67 58.51,37.67
DGND on L10_SIG03 (solid shape): 40.16,123.74 40.18,123.73 40.2,123.72 40.68,123.24 40.69,123.21 40.69,123.18 40.68,123.17 40.66,123.15 31.96,123.15 31.93,123.16 31.91,123.18 31.87,123.29 31.87,123.32 31.89,123.33 31.97,123.46 31.98,123.62 31.97,123.63 31.98,123.65 32.04,123.72 32.06,123.73 32.08,123.74
DGND on L10_SIG03 (solid shape): 49.33,145.42 49.35,145.41 49.37,145.4 50.53,144.24 50.55,144.2 50.52,144.15 50.48,144.14 50.45,144.16 49.5,145.11 49.48,145.12 49.46,145.13 48.32,145.13 48.29,145.13 48.27,145.16 48.27,145.17 48.27,145.2 48.47,145.4 48.49,145.41 48.51,145.42
DGND on L10_SIG03 (solid shape): 48.52,104.71 49.16,104.07 49.18,104.06 49.2,104.05 51.45,104.05 51.47,104.05 51.48,104.04 51.54,103.99 51.54,103.89 51.5,103.88 48.98,103.88 48.96,103.88 48.94,103.89 48.46,104.38 48.45,104.39 48.44,104.41 48.44,104.67 48.45,104.69 48.47,104.71 48.49,104.72
DGND on L10_SIG03 (solid shape): 13.55,109.49 13.62,109.44 13.64,109.42 13.64,109.4 13.64,108.81 13.65,108.79 13.66,108.78 16.87,105.57 16.88,105.54 16.88,105.51 16.87,105.5 16.85,105.48 16.39,105.48 16.37,105.48 16.36,105.49 13.39,108.46 13.38,108.47 13.38,108.49 13.38,109.39 13.38,109.41 13.39,109.42 13.44,109.48 13.53,109.5
DGND on L10_SIG03 (solid shape): 70.9,151.1 70.93,151.08 71.24,150.77 71.25,150.75 71.26,150.73 71.26,150.43 71.25,150.41 71.24,150.39 69.81,148.96 69.8,148.95 69.78,148.94 69.52,148.94 69.49,148.95 69.48,148.98 69.47,148.99 69.48,149.02 70.82,150.36 70.83,150.38 70.83,150.4 70.83,151.03
DGND on L10_SIG03 (solid shape): 28.21,99.13 28.28,99.07 28.3,99.06 28.3,99.01 28.29,99 27.08,97.79 27.06,97.78 27.04,97.77 26.47,97.77 26.45,97.77 26.43,97.75 26.4,97.76 26.37,97.78 26.36,97.81 26.36,98.01 26.37,98.03 26.38,98.05 27.44,99.11 27.46,99.12 27.48,99.12 28.1,99.12 28.14,99.13 28.19,99.14
DGND on L10_SIG03 (solid shape): 36.47,46.15 36.5,46.14 36.52,46.12 36.52,46.11 36.52,46.08 35.67,45.23 35.66,45.21 35.65,45.19 35.65,44.72 35.65,44.7 35.64,44.69 35.16,44.2 35.13,44.19 35.1,44.19 35.09,44.2 35.07,44.22 35.07,45.6 35.07,45.62 35.09,45.64 35.22,45.77 35.24,45.78 35.25,45.78 35.79,45.78 35.81,45.79 35.82,45.8 36.16,46.14 36.18,46.15 36.2,46.15
DGND on L10_SIG03 (solid shape): 17.07,136.15 17.1,136.16 17.14,136.15 17.16,136.09 17.15,136.07 14.87,133.79 14.86,133.78 14.84,133.77 13.57,133.77 13.55,133.77 13.54,133.76 12.72,132.95 12.7,132.93 12.67,132.94 12.66,132.94 12.64,132.97 12.64,133.49 12.64,133.51 12.65,133.52 13.31,134.18 13.33,134.19 13.35,134.2 15.09,134.2 15.11,134.2 15.13,134.21
DGND on L10_SIG03 (solid shape): 29.02,102.35 29.04,102.37 29.07,102.37 29.16,102.34 29.18,102.32 29.19,102.3 29.25,102.17 29.36,102.08 29.38,102.07 29.39,102.05 29.41,101.96 29.4,101.94 29.39,101.91 28.97,101.5 28.96,101.49 28.94,101.48 27.84,101.48 27.81,101.49 27.79,101.51 27.78,101.53 27.79,101.56 28.26,102.03 28.28,102.04 28.3,102.05 28.68,102.05 28.7,102.05 28.72,102.06
DGND on L10_SIG03 (solid shape): 49.85,111 50.08,110.77 50.09,110.74 50.08,110.7 48.51,109.13 48.49,109.12 48.47,109.12 47.91,109.12 47.89,109.12 47.87,109.14 47.81,109.2 47.81,109.26 47.81,109.33 47.87,109.39 47.89,109.41 47.91,109.41 48.4,109.41 48.42,109.41 48.43,109.43 49.76,110.75 49.77,110.77 49.77,110.79 49.77,110.95 49.78,110.98 49.8,111 49.82,111
DGND on L10_SIG03 (solid shape): 16.67,136.59 16.69,136.58 16.71,136.56 16.72,136.54 16.71,136.51 15.26,135.06 15.24,135.05 15.22,135.04 15.13,135.05 15.11,135.07 15.01,135.15 14.9,135.19 14.87,135.2 13.88,136.19 13.86,136.2 13.85,136.2 12.71,136.2 12.68,136.21 12.66,136.23 12.61,136.31 12.61,136.34 12.64,136.4 12.66,136.48 12.75,136.58 12.77,136.59 12.79,136.59
DGND on L10_SIG03 (solid shape): 40.67,146.45 40.7,146.47 40.73,146.46 40.74,146.46 40.76,146.43 40.76,145.23 40.76,145.21 40.77,145.19 41.33,144.63 41.35,144.62 41.37,144.62 45.36,144.62 45.38,144.61 45.4,144.6 45.45,144.53 45.46,144.45 45.46,144.39 45.46,144.37 45.4,144.3 45.38,144.29 45.36,144.28 41.13,144.28 41.11,144.28 41.1,144.3 40.27,145.12 40.26,145.14 40.26,145.16 40.26,146.02 40.26,146.04 40.27,146.05
DGND on L10_SIG03 (solid shape): 32.18,125.87 32.2,125.87 32.22,125.86 32.61,125.47 32.63,125.46 32.65,125.45 36.72,125.45 36.74,125.45 36.76,125.43 36.82,125.36 36.82,125.34 36.81,125.3 36.79,125.28 36.77,125.27 36.75,125.26 28.05,125.26 28.02,125.27 28,125.29 27.96,125.4 27.97,125.43 27.98,125.44 28.07,125.58 28.08,125.75 28.07,125.76 28.08,125.78 28.14,125.85 28.15,125.87 28.17,125.87
DGND on L10_SIG03 (solid shape): 71.3,151.93 71.32,151.93 71.34,151.92 72.28,150.98 72.29,150.96 72.29,150.94 72.29,150.36 72.29,150.34 72.28,150.32 70.47,148.51 70.45,148.5 70.43,148.5 70.19,148.5 70.16,148.5 70.14,148.53 70.14,148.54 70.14,148.57 71.75,150.18 71.76,150.2 71.77,150.22 71.77,150.94 71.76,150.96 71.75,150.98 71.04,151.7 71.02,151.72 71.02,151.75 71.05,151.84 71.07,151.86 71.14,151.89 71.22,151.93
DGND on L10_SIG03 (solid shape): 37.39,48.1 37.42,48.09 37.44,48.06 37.44,48.05 37.44,48.02 37,47.58 36.98,47.57 36.96,47.57 32.88,47.57 32.86,47.57 32.85,47.55 31.94,46.64 31.9,46.64 31.89,46.65 31.73,46.69 31.58,46.65 31.56,46.65 31.53,46.65 31.52,46.66 31.5,46.7 31.52,46.74 31.54,46.76 31.54,46.78 31.54,47.51 31.55,47.53 31.56,47.54 32.1,48.08 32.11,48.09 32.13,48.1
DGND on L10_SIG03 (solid shape): 26.34,108.29 26.36,108.28 26.38,108.26 26.39,108.25 26.38,108.22 25.93,107.76 25.91,107.74 25.91,107.72 25.91,107.42 25.91,107.4 25.9,107.38 25.4,106.89 25.38,106.88 25.36,106.87 23.41,106.87 23.39,106.87 23.37,106.86 22.23,105.72 22.22,105.71 22.2,105.71 21.98,105.71 21.96,105.72 21.94,105.74 21.93,105.75 21.94,105.78 23.57,107.42 23.59,107.43 23.61,107.43 25.22,107.43 25.24,107.43 25.25,107.44 26.09,108.28 26.1,108.29 26.12,108.29
DGND on L10_SIG03 (solid shape): 54.02,148.43 54.04,148.42 54.06,148.4 54.11,148.31 54.11,148.28 54.1,148.27 54.05,148.17 54.04,148.06 54.04,148.03 53.98,147.97 53.96,147.96 53.94,147.95 47.19,147.95 47.17,147.96 47.15,147.97 46.92,148.2 46.9,148.21 46.88,148.21 45.63,148.21 45.61,148.21 45.58,148.19 45.54,148.19 45.52,148.21 45.48,148.29 45.49,148.32 45.54,148.4 45.56,148.42 45.58,148.43
DGND on L10_SIG03 (solid shape): 57.52,44.54 57.55,44.53 57.57,44.51 57.61,44.4 57.6,44.37 57.59,44.36 57.48,44.19 57.5,43.99 57.5,43.97 57.5,43.95 57.44,43.87 57.43,43.85 57.4,43.85 57.11,43.85 57.09,43.84 57.07,43.83 56.33,43.08 56.31,43.07 56.29,43.07 52.56,43.07 52.53,43.08 52.52,43.1 52.51,43.11 52.52,43.14 52.79,43.42 52.81,43.44 52.81,43.46 52.81,44.37 52.81,44.39 52.82,44.4 52.95,44.52 52.96,44.54 52.98,44.54
DGND on L10_SIG03 (solid shape): 48.01,112.95 48.87,112.08 48.88,112.06 48.89,112.04 48.89,111.8 48.88,111.78 48.87,111.76 48.78,111.67 48.75,111.65 48.73,111.66 48.63,111.69 48.61,111.71 48.61,111.72 48.46,111.94 48.19,111.98 48.18,111.98 48.15,111.99 47.8,112.34 47.8,112.36 47.8,112.38 47.81,112.51 47.76,112.64 47.75,112.66 47.75,112.69 47.92,112.85 47.93,112.87 47.94,112.93 47.96,112.95 47.98,112.95
DGND on L10_SIG03 (solid shape): 65.52,56.41 65.53,56.4 66.24,56.07 66.99,56.33 67,56.34 67.03,56.34 67.12,56.3 67.15,56.28 67.15,56.25 67.15,54.09 67.15,54.07 67.14,54.05 66.58,53.5 66.56,53.48 66.55,53.48 65.93,53.48 65.91,53.48 65.9,53.47 65.44,53.01 65.42,53 65.39,53 65.37,53.01 65.36,53.03 65.36,56.33 65.37,56.36 65.39,56.37 65.49,56.41
DGND on L10_SIG03 (solid shape): 20.34,130.05 20.36,130.03 20.37,130 20.37,127.98 20.37,127.96 20.36,127.94 19.19,126.77 19.17,126.76 19.15,126.76 18.04,126.76 18.01,126.77 17.99,126.79 17.98,126.81 17.99,126.84 18.53,127.38 18.54,127.39 18.55,127.41 18.55,129.86 18.55,129.88 18.57,129.9 18.67,129.95 18.7,129.94 18.71,129.93 19.48,129.69 20.19,130.06 20.2,130.08 20.23,130.09
DGND on L10_SIG03 (solid shape): 6.66,122.36 6.68,122.35 7.08,122.11 7.54,122.03 7.56,122.03 7.58,122.01 7.63,121.91 7.63,121.88 7.62,121.86 7.33,121.57 7.32,121.55 7.32,121.54 7.32,112.69 7.31,112.66 7.3,112.64 7.22,112.59 7.19,112.59 7.18,112.59 7.1,112.61 7.03,112.61 6.99,112.62 6.93,112.67 6.92,112.69 6.91,112.71 6.91,121.51 6.91,121.53 6.9,121.55 6.52,121.92 6.51,121.94 6.51,121.96 6.51,122.28 6.51,122.31 6.54,122.33 6.64,122.37
DGND on L10_SIG03 (solid shape): 27.04,102.24 27.06,102.25 27.08,102.26 27.18,102.24 27.2,102.23 27.2,102.22 27.28,102.13 27.38,102.07 27.39,102.06 27.4,102.04 27.43,101.95 27.42,101.92 27.41,101.9 26.37,100.86 26.35,100.85 26.33,100.84 24.62,100.84 24.6,100.84 24.59,100.83 24.34,100.59 24.33,100.57 24.31,100.57 23.68,100.57 23.57,100.63 23.47,100.65 23.46,100.65 23.43,100.66 23.39,100.77 23.39,100.79 23.41,100.82 24.22,101.64 24.24,101.65 24.26,101.65 26.43,101.65 26.45,101.66 26.47,101.67
